v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 1940 -570 2740 -170 {flags=graph
y1=0
y2=3.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.25e-08
x2=2.625e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 6 12 10 17 13"
node="out5
out6
out7
out8
out9
in"}
B 2 1940 -970 2740 -570 {flags=graph
y1=-5.9e-07
y2=2.3e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.25e-08
x2=2.625e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 1 12 10 14"
node="i(vmeas5)
i(vmeas6)
i(vmeas7)
i(vmeas8)
i(vmeas9)"}
B 2 2740 -570 3540 -170 {flags=graph
y1=-0.071
y2=3.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.25e-08
x2=2.625e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 6 12 10 14 13"
node="o5
o6
o7
o8
o9
in"}
B 2 2740 -970 3540 -570 {flags=graph
y1=0
y2=3.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.25e-08
x2=2.625e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="13 4 6 12 10 14"
node="in
a5
a6
a7
a8
a9"}
B 2 3540 -970 4340 -570 {flags=graph
y1=0
y2=3.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.25e-08
x2=2.625e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="13 4 1 12"
node="in
a8
a8b
a8t"}
B 2 3540 -570 4340 -170 {flags=graph
y1=0
y2=3.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.25e-08
x2=2.625e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="13 4 1 12"
node="in
ab8
ab8b
ab8t"}
B 2 4430 -570 5230 -170 {flags=graph
y1=-0.072
y2=3.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.25e-08
x2=2.625e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 6 12 10 14 13"
node="o5d
o6d
o7d
o8d
o9d
ind"}
B 2 5230 -970 6030 -570 {flags=graph
y1=0
y2=3.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.25e-08
x2=2.625e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color=4
node=ind}
B 2 4430 -970 5230 -570 {flags=graph
y1=-8.5934585e-07
y2=1.507901e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.25e-08
x2=2.625e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 1 12 10 14"
node="i(vmeas15)
i(vmeas16)
i(vmeas17)
i(vmeas18)
i(vmeas19)"}
N 240 -1080 280 -1080 {lab=o10}
N 170 -1010 170 -990 {lab=0}
N 1480 -970 1480 -960 {lab=GND}
N 1480 -960 1750 -960 {lab=GND}
N 1750 -970 1750 -960 {lab=GND}
N 1480 -1220 1480 -1210 {lab=#net1}
N 1480 -1220 1750 -1220 {lab=#net1}
N 1750 -1220 1750 -1210 {lab=#net1}
N 1620 -1230 1620 -1220 {lab=#net1}
N 1620 -960 1620 -950 {lab=GND}
N 1440 -1090 1440 -1060 {lab=out}
N 1440 -1090 1480 -1090 {lab=out}
N 1440 -1120 1440 -1090 {lab=out}
N 1750 -1150 1750 -1030 {lab=out}
N 1480 -1090 1750 -1090 {lab=out}
N 1480 -1060 1490 -1060 {lab=GND}
N 1490 -1060 1490 -960 {lab=GND}
N 1480 -1120 1490 -1120 {lab=#net1}
N 1490 -1220 1490 -1120 {lab=#net1}
N 1480 -1000 1490 -1000 {lab=GND}
N 1480 -1180 1490 -1180 {lab=#net1}
N 600 -170 600 -160 {lab=GND}
N 880 -170 880 -160 {lab=GND}
N 600 -320 600 -310 {lab=#net2}
N 880 -320 880 -310 {lab=#net3}
N 840 -280 840 -200 {lab=in}
N 880 -250 880 -230 {lab=o2}
N 560 -280 560 -200 {lab=in}
N 600 -250 600 -230 {lab=o1}
N 1750 -410 1750 -400 {lab=VDD}
N 1750 -160 1750 -150 {lab=GND}
N 1750 -340 1750 -220 {lab=out2}
N 1580 -280 1750 -280 {lab=out2}
N 1580 -410 1580 -400 {lab=VDD2}
N 1480 -550 1480 -540 {lab=GND}
N 1480 -540 1750 -540 {lab=GND}
N 1750 -550 1750 -540 {lab=GND}
N 1480 -800 1480 -790 {lab=#net4}
N 1480 -800 1750 -800 {lab=#net4}
N 1750 -800 1750 -790 {lab=#net4}
N 1620 -810 1620 -800 {lab=#net4}
N 1620 -540 1620 -530 {lab=GND}
N 1440 -670 1440 -640 {lab=out3}
N 1440 -670 1480 -670 {lab=out3}
N 1440 -700 1440 -670 {lab=out3}
N 1750 -730 1750 -610 {lab=out3}
N 1480 -670 1750 -670 {lab=out3}
N 850 -920 850 -910 {lab=GND}
N 850 -910 1120 -910 {lab=GND}
N 1120 -920 1120 -910 {lab=GND}
N 850 -1290 850 -1280 {lab=#net5}
N 850 -1290 1120 -1290 {lab=#net5}
N 1120 -1290 1120 -1280 {lab=#net5}
N 990 -1300 990 -1290 {lab=#net5}
N 990 -910 990 -900 {lab=GND}
N 1120 -1160 1120 -1040 {lab=out4}
N 850 -1100 1120 -1100 {lab=out4}
N 1120 -1040 1120 -980 {lab=out4}
N 1120 -1220 1120 -1160 {lab=out4}
N 850 -1220 850 -1160 {lab=#net6}
N 850 -1040 850 -980 {lab=#net7}
N 2370 -2640 2370 -2630 {lab=GND}
N 2330 -2760 2370 -2760 {lab=a5}
N 2330 -2790 2330 -2760 {lab=a5}
N 2330 -2760 2330 -2730 {lab=a5}
N 2370 -2260 2370 -2250 {lab=GND}
N 2330 -2380 2370 -2380 {lab=a6}
N 2330 -2410 2330 -2380 {lab=a6}
N 2330 -2380 2330 -2350 {lab=a6}
N 2370 -1880 2370 -1870 {lab=GND}
N 2330 -2000 2370 -2000 {lab=a7}
N 2330 -2030 2330 -2000 {lab=a7}
N 2330 -2000 2330 -1970 {lab=a7}
N 2370 -1500 2370 -1490 {lab=GND}
N 2330 -1620 2370 -1620 {lab=a8}
N 2330 -1650 2330 -1620 {lab=a8}
N 2330 -1620 2330 -1590 {lab=a8}
N 2370 -1110 2370 -1100 {lab=GND}
N 2330 -1230 2370 -1230 {lab=a9}
N 2330 -1260 2330 -1230 {lab=a9}
N 2330 -1230 2330 -1200 {lab=a9}
N 2300 -1140 2330 -1140 {lab=in}
N 2300 -1320 2300 -1140 {lab=in}
N 2300 -1320 2330 -1320 {lab=in}
N 2300 -1530 2330 -1530 {lab=in}
N 2300 -1710 2300 -1530 {lab=in}
N 2300 -1710 2330 -1710 {lab=in}
N 2300 -2090 2330 -2090 {lab=in}
N 2300 -2090 2300 -1910 {lab=in}
N 2300 -1910 2330 -1910 {lab=in}
N 2300 -2290 2330 -2290 {lab=in}
N 2300 -2470 2300 -2290 {lab=in}
N 2300 -2470 2330 -2470 {lab=in}
N 2300 -2850 2330 -2850 {lab=in}
N 2300 -2850 2300 -2670 {lab=in}
N 2300 -2670 2330 -2670 {lab=in}
N 4990 -1230 5360 -1230 {lab=o9}
N 4990 -2000 5360 -2000 {lab=o7}
N 4990 -1620 5360 -1620 {lab=o8}
N 4990 -2760 5360 -2760 {lab=o5}
N 4990 -2380 5360 -2380 {lab=o6}
N 2330 -1230 2370 -1230 {lab=a9}
N 2370 -1350 2630 -1350 {lab=#net8}
N 2370 -1230 2630 -1230 {lab=a9}
N 2630 -1290 2630 -1230 {lab=a9}
N 2630 -1230 2630 -1170 {lab=a9}
N 2370 -1110 2630 -1110 {lab=GND}
N 2670 -1140 2670 -1080 {lab=in}
N 2300 -1080 2670 -1080 {lab=in}
N 2300 -1140 2300 -1080 {lab=in}
N 2670 -1430 2670 -1320 {lab=in}
N 2300 -1430 2670 -1430 {lab=in}
N 2300 -1430 2300 -1320 {lab=in}
N 2330 -2760 2370 -2760 {lab=a5}
N 2370 -2880 2630 -2880 {lab=#net9}
N 2370 -2760 2630 -2760 {lab=a5}
N 2630 -2820 2630 -2760 {lab=a5}
N 2630 -2760 2630 -2700 {lab=a5}
N 2370 -2640 2630 -2640 {lab=GND}
N 2670 -2670 2670 -2610 {lab=in}
N 2300 -2610 2670 -2610 {lab=in}
N 2300 -2670 2300 -2610 {lab=in}
N 2670 -2960 2670 -2850 {lab=in}
N 2300 -2960 2670 -2960 {lab=in}
N 2300 -2960 2300 -2850 {lab=in}
N 2330 -2380 2370 -2380 {lab=a6}
N 2370 -2500 2630 -2500 {lab=#net10}
N 2370 -2380 2630 -2380 {lab=a6}
N 2630 -2440 2630 -2380 {lab=a6}
N 2630 -2380 2630 -2320 {lab=a6}
N 2370 -2260 2630 -2260 {lab=GND}
N 2670 -2290 2670 -2230 {lab=in}
N 2300 -2230 2670 -2230 {lab=in}
N 2300 -2290 2300 -2230 {lab=in}
N 2670 -2580 2670 -2470 {lab=in}
N 2300 -2580 2670 -2580 {lab=in}
N 2300 -2580 2300 -2470 {lab=in}
N 2330 -2000 2370 -2000 {lab=a7}
N 2370 -2120 2630 -2120 {lab=#net11}
N 2370 -2000 2630 -2000 {lab=a7}
N 2630 -2060 2630 -2000 {lab=a7}
N 2630 -2000 2630 -1940 {lab=a7}
N 2370 -1880 2630 -1880 {lab=GND}
N 2670 -1910 2670 -1850 {lab=in}
N 2300 -1850 2670 -1850 {lab=in}
N 2300 -1910 2300 -1850 {lab=in}
N 2670 -2200 2670 -2090 {lab=in}
N 2300 -2200 2670 -2200 {lab=in}
N 2300 -2200 2300 -2090 {lab=in}
N 2330 -1620 2370 -1620 {lab=a8}
N 2370 -1740 2630 -1740 {lab=#net12}
N 2370 -1620 2630 -1620 {lab=a8}
N 2630 -1680 2630 -1620 {lab=a8}
N 2630 -1620 2630 -1560 {lab=a8}
N 2370 -1500 2630 -1500 {lab=GND}
N 2670 -1530 2670 -1470 {lab=in}
N 2300 -1470 2670 -1470 {lab=in}
N 2300 -1530 2300 -1470 {lab=in}
N 2670 -1820 2670 -1710 {lab=in}
N 2300 -1820 2670 -1820 {lab=in}
N 2300 -1820 2300 -1710 {lab=in}
N 5360 -1230 5440 -1230 {lab=o9}
N 5360 -1620 5440 -1620 {lab=o8}
N 5360 -2380 5440 -2380 {lab=o6}
N 5360 -2000 5440 -2000 {lab=o7}
N 5360 -2760 5440 -2760 {lab=o5}
N 2630 -1230 2940 -1230 {lab=a9}
N 2630 -1620 2940 -1620 {lab=a8}
N 2630 -2000 2940 -2000 {lab=a7}
N 2630 -2380 2940 -2380 {lab=a6}
N 2630 -2760 2940 -2760 {lab=a5}
N 1760 -1500 1760 -1490 {lab=GND}
N 1720 -1620 1760 -1620 {lab=ab8}
N 1720 -1650 1720 -1620 {lab=ab8}
N 1720 -1620 1720 -1590 {lab=ab8}
N 1690 -1530 1720 -1530 {lab=in}
N 1690 -1710 1690 -1530 {lab=in}
N 1690 -1710 1720 -1710 {lab=in}
N 1720 -1620 1760 -1620 {lab=ab8}
N 1760 -1740 2020 -1740 {lab=#net13}
N 1760 -1620 2020 -1620 {lab=ab8}
N 2020 -1680 2020 -1620 {lab=ab8}
N 2020 -1620 2020 -1560 {lab=ab8}
N 1760 -1500 2020 -1500 {lab=GND}
N 2060 -1530 2060 -1470 {lab=in}
N 1690 -1470 2060 -1470 {lab=in}
N 1690 -1530 1690 -1470 {lab=in}
N 2060 -1820 2060 -1710 {lab=in}
N 1690 -1820 2060 -1820 {lab=in}
N 1690 -1820 1690 -1710 {lab=in}
N 1760 -1680 1850 -1680 {lab=ab8t}
N 1760 -1560 1850 -1560 {lab=ab8b}
N 2020 -1620 2090 -1620 {lab=ab8}
N 1260 -1500 1260 -1490 {lab=GND}
N 1220 -1620 1260 -1620 {lab=ac8}
N 1220 -1650 1220 -1620 {lab=ac8}
N 1220 -1620 1220 -1590 {lab=ac8}
N 1190 -1530 1220 -1530 {lab=in}
N 1190 -1710 1190 -1530 {lab=in}
N 1190 -1710 1220 -1710 {lab=in}
N 1220 -1620 1260 -1620 {lab=ac8}
N 1260 -1740 1520 -1740 {lab=#net14}
N 1260 -1620 1520 -1620 {lab=ac8}
N 1520 -1680 1520 -1620 {lab=ac8}
N 1520 -1620 1520 -1560 {lab=ac8}
N 1260 -1500 1520 -1500 {lab=GND}
N 1560 -1530 1560 -1470 {lab=in}
N 1190 -1470 1560 -1470 {lab=in}
N 1190 -1530 1190 -1470 {lab=in}
N 1560 -1820 1560 -1710 {lab=in}
N 1190 -1820 1560 -1820 {lab=in}
N 1190 -1820 1190 -1710 {lab=in}
N 1260 -1680 1350 -1680 {lab=ac8t}
N 1260 -1560 1350 -1560 {lab=ac8b}
N 1520 -1620 1580 -1620 {lab=ac8}
N 3010 -2640 3010 -2630 {lab=GND}
N 2970 -2760 3010 -2760 {lab=#net15}
N 2970 -2790 2970 -2760 {lab=#net15}
N 2970 -2760 2970 -2730 {lab=#net15}
N 3010 -2260 3010 -2250 {lab=GND}
N 2970 -2380 3010 -2380 {lab=#net16}
N 2970 -2410 2970 -2380 {lab=#net16}
N 2970 -2380 2970 -2350 {lab=#net16}
N 3010 -1880 3010 -1870 {lab=GND}
N 2970 -2000 3010 -2000 {lab=#net17}
N 2970 -2030 2970 -2000 {lab=#net17}
N 2970 -2000 2970 -1970 {lab=#net17}
N 3010 -1500 3010 -1490 {lab=GND}
N 2970 -1620 3010 -1620 {lab=#net18}
N 2970 -1650 2970 -1620 {lab=#net18}
N 2970 -1620 2970 -1590 {lab=#net18}
N 3010 -1110 3010 -1100 {lab=GND}
N 2970 -1230 3010 -1230 {lab=#net19}
N 2970 -1260 2970 -1230 {lab=#net19}
N 2970 -1230 2970 -1200 {lab=#net19}
N 2940 -1140 2970 -1140 {lab=a9}
N 2940 -1320 2940 -1140 {lab=a9}
N 2940 -1320 2970 -1320 {lab=a9}
N 2940 -1530 2970 -1530 {lab=a8}
N 2940 -1710 2940 -1530 {lab=a8}
N 2940 -1710 2970 -1710 {lab=a8}
N 2940 -2090 2970 -2090 {lab=a7}
N 2940 -2090 2940 -1910 {lab=a7}
N 2940 -1910 2970 -1910 {lab=a7}
N 2940 -2290 2970 -2290 {lab=a6}
N 2940 -2470 2940 -2290 {lab=a6}
N 2940 -2470 2970 -2470 {lab=a6}
N 2940 -2850 2970 -2850 {lab=a5}
N 2940 -2850 2940 -2670 {lab=a5}
N 2940 -2670 2970 -2670 {lab=a5}
N 2970 -1230 3010 -1230 {lab=#net19}
N 3010 -1350 3270 -1350 {lab=VDD}
N 3010 -1230 3270 -1230 {lab=#net19}
N 3270 -1290 3270 -1230 {lab=#net19}
N 3270 -1230 3270 -1170 {lab=#net19}
N 3010 -1110 3270 -1110 {lab=GND}
N 3310 -1140 3310 -1080 {lab=a9}
N 2940 -1080 3310 -1080 {lab=a9}
N 2940 -1140 2940 -1080 {lab=a9}
N 3310 -1430 3310 -1320 {lab=a9}
N 2940 -1430 3310 -1430 {lab=a9}
N 2940 -1430 2940 -1320 {lab=a9}
N 2970 -2760 3010 -2760 {lab=#net15}
N 3010 -2880 3270 -2880 {lab=VDD}
N 3010 -2760 3270 -2760 {lab=#net15}
N 3270 -2820 3270 -2760 {lab=#net15}
N 3270 -2760 3270 -2700 {lab=#net15}
N 3010 -2640 3270 -2640 {lab=GND}
N 3310 -2670 3310 -2610 {lab=a5}
N 2940 -2610 3310 -2610 {lab=a5}
N 2940 -2670 2940 -2610 {lab=a5}
N 3310 -2960 3310 -2850 {lab=a5}
N 2940 -2960 3310 -2960 {lab=a5}
N 2940 -2960 2940 -2850 {lab=a5}
N 2970 -2380 3010 -2380 {lab=#net16}
N 3010 -2500 3270 -2500 {lab=VDD}
N 3010 -2380 3270 -2380 {lab=#net16}
N 3270 -2440 3270 -2380 {lab=#net16}
N 3270 -2380 3270 -2320 {lab=#net16}
N 3010 -2260 3270 -2260 {lab=GND}
N 3310 -2290 3310 -2230 {lab=a6}
N 2940 -2230 3310 -2230 {lab=a6}
N 2940 -2290 2940 -2230 {lab=a6}
N 3310 -2580 3310 -2470 {lab=a6}
N 2940 -2580 3310 -2580 {lab=a6}
N 2940 -2580 2940 -2470 {lab=a6}
N 2970 -2000 3010 -2000 {lab=#net17}
N 3010 -2120 3270 -2120 {lab=VDD}
N 3010 -2000 3270 -2000 {lab=#net17}
N 3270 -2060 3270 -2000 {lab=#net17}
N 3270 -2000 3270 -1940 {lab=#net17}
N 3010 -1880 3270 -1880 {lab=GND}
N 3310 -1910 3310 -1850 {lab=a7}
N 2940 -1850 3310 -1850 {lab=a7}
N 2940 -1910 2940 -1850 {lab=a7}
N 3310 -2200 3310 -2090 {lab=a7}
N 2940 -2200 3310 -2200 {lab=a7}
N 2940 -2200 2940 -2090 {lab=a7}
N 2970 -1620 3010 -1620 {lab=#net18}
N 3010 -1740 3270 -1740 {lab=VDD}
N 3010 -1620 3270 -1620 {lab=#net18}
N 3270 -1680 3270 -1620 {lab=#net18}
N 3270 -1620 3270 -1560 {lab=#net18}
N 3010 -1500 3270 -1500 {lab=GND}
N 3310 -1530 3310 -1470 {lab=a8}
N 2940 -1470 3310 -1470 {lab=a8}
N 2940 -1530 2940 -1470 {lab=a8}
N 3310 -1820 3310 -1710 {lab=a8}
N 2940 -1820 3310 -1820 {lab=a8}
N 2940 -1820 2940 -1710 {lab=a8}
N 3270 -2760 3350 -2760 {lab=#net15}
N 3010 -2940 3010 -2880 {lab=VDD}
N 3010 -2560 3010 -2500 {lab=VDD}
N 3270 -2380 3350 -2380 {lab=#net16}
N 3010 -2180 3010 -2120 {lab=VDD}
N 3010 -1800 3010 -1740 {lab=VDD}
N 3270 -2000 3350 -2000 {lab=#net17}
N 3270 -1620 3350 -1620 {lab=#net18}
N 3010 -1410 3010 -1350 {lab=VDD}
N 3270 -1230 3340 -1230 {lab=#net19}
N 3340 -1230 3350 -1230 {lab=#net19}
N 3420 -2640 3420 -2630 {lab=GND}
N 3380 -2760 3420 -2760 {lab=#net20}
N 3380 -2790 3380 -2760 {lab=#net20}
N 3380 -2760 3380 -2730 {lab=#net20}
N 3420 -2260 3420 -2250 {lab=GND}
N 3380 -2380 3420 -2380 {lab=#net21}
N 3380 -2410 3380 -2380 {lab=#net21}
N 3380 -2380 3380 -2350 {lab=#net21}
N 3420 -1880 3420 -1870 {lab=GND}
N 3380 -2000 3420 -2000 {lab=#net22}
N 3380 -2030 3380 -2000 {lab=#net22}
N 3380 -2000 3380 -1970 {lab=#net22}
N 3420 -1500 3420 -1490 {lab=GND}
N 3380 -1620 3420 -1620 {lab=#net23}
N 3380 -1650 3380 -1620 {lab=#net23}
N 3380 -1620 3380 -1590 {lab=#net23}
N 3420 -1110 3420 -1100 {lab=GND}
N 3380 -1230 3420 -1230 {lab=#net24}
N 3380 -1260 3380 -1230 {lab=#net24}
N 3380 -1230 3380 -1200 {lab=#net24}
N 3350 -1140 3380 -1140 {lab=#net19}
N 3350 -1320 3350 -1140 {lab=#net19}
N 3350 -1320 3380 -1320 {lab=#net19}
N 3350 -1530 3380 -1530 {lab=#net18}
N 3350 -1710 3350 -1530 {lab=#net18}
N 3350 -1710 3380 -1710 {lab=#net18}
N 3350 -2090 3380 -2090 {lab=#net17}
N 3350 -2090 3350 -1910 {lab=#net17}
N 3350 -1910 3380 -1910 {lab=#net17}
N 3350 -2290 3380 -2290 {lab=#net16}
N 3350 -2470 3350 -2290 {lab=#net16}
N 3350 -2470 3380 -2470 {lab=#net16}
N 3350 -2850 3380 -2850 {lab=#net15}
N 3350 -2850 3350 -2670 {lab=#net15}
N 3350 -2670 3380 -2670 {lab=#net15}
N 3380 -1230 3420 -1230 {lab=#net24}
N 3420 -1350 3680 -1350 {lab=VDD}
N 3420 -1230 3680 -1230 {lab=#net24}
N 3680 -1290 3680 -1230 {lab=#net24}
N 3680 -1230 3680 -1170 {lab=#net24}
N 3420 -1110 3680 -1110 {lab=GND}
N 3720 -1140 3720 -1080 {lab=#net19}
N 3350 -1080 3720 -1080 {lab=#net19}
N 3350 -1140 3350 -1080 {lab=#net19}
N 3720 -1430 3720 -1320 {lab=#net19}
N 3350 -1430 3720 -1430 {lab=#net19}
N 3350 -1430 3350 -1320 {lab=#net19}
N 3380 -2760 3420 -2760 {lab=#net20}
N 3420 -2880 3680 -2880 {lab=VDD}
N 3420 -2760 3680 -2760 {lab=#net20}
N 3680 -2820 3680 -2760 {lab=#net20}
N 3680 -2760 3680 -2700 {lab=#net20}
N 3420 -2640 3680 -2640 {lab=GND}
N 3720 -2670 3720 -2610 {lab=#net15}
N 3350 -2610 3720 -2610 {lab=#net15}
N 3350 -2670 3350 -2610 {lab=#net15}
N 3720 -2960 3720 -2850 {lab=#net15}
N 3350 -2960 3720 -2960 {lab=#net15}
N 3350 -2960 3350 -2850 {lab=#net15}
N 3380 -2380 3420 -2380 {lab=#net21}
N 3420 -2500 3680 -2500 {lab=VDD}
N 3420 -2380 3680 -2380 {lab=#net21}
N 3680 -2440 3680 -2380 {lab=#net21}
N 3680 -2380 3680 -2320 {lab=#net21}
N 3420 -2260 3680 -2260 {lab=GND}
N 3720 -2290 3720 -2230 {lab=#net16}
N 3350 -2230 3720 -2230 {lab=#net16}
N 3350 -2290 3350 -2230 {lab=#net16}
N 3720 -2580 3720 -2470 {lab=#net16}
N 3350 -2580 3720 -2580 {lab=#net16}
N 3350 -2580 3350 -2470 {lab=#net16}
N 3380 -2000 3420 -2000 {lab=#net22}
N 3420 -2120 3680 -2120 {lab=VDD}
N 3420 -2000 3680 -2000 {lab=#net22}
N 3680 -2060 3680 -2000 {lab=#net22}
N 3680 -2000 3680 -1940 {lab=#net22}
N 3420 -1880 3680 -1880 {lab=GND}
N 3720 -1910 3720 -1850 {lab=#net17}
N 3350 -1850 3720 -1850 {lab=#net17}
N 3350 -1910 3350 -1850 {lab=#net17}
N 3720 -2200 3720 -2090 {lab=#net17}
N 3350 -2200 3720 -2200 {lab=#net17}
N 3350 -2200 3350 -2090 {lab=#net17}
N 3380 -1620 3420 -1620 {lab=#net23}
N 3420 -1740 3680 -1740 {lab=VDD}
N 3680 -1680 3680 -1620 {lab=#net23}
N 3680 -1620 3680 -1560 {lab=#net23}
N 3420 -1500 3680 -1500 {lab=GND}
N 3720 -1530 3720 -1470 {lab=#net18}
N 3350 -1470 3720 -1470 {lab=#net18}
N 3350 -1530 3350 -1470 {lab=#net18}
N 3720 -1820 3720 -1710 {lab=#net18}
N 3350 -1820 3720 -1820 {lab=#net18}
N 3350 -1820 3350 -1710 {lab=#net18}
N 3680 -2760 3760 -2760 {lab=#net20}
N 3420 -2940 3420 -2880 {lab=VDD}
N 3420 -2560 3420 -2500 {lab=VDD}
N 3680 -2380 3760 -2380 {lab=#net21}
N 3420 -2180 3420 -2120 {lab=VDD}
N 3420 -1800 3420 -1740 {lab=VDD}
N 3680 -2000 3760 -2000 {lab=#net22}
N 3680 -1620 3760 -1620 {lab=#net23}
N 3420 -1410 3420 -1350 {lab=VDD}
N 3680 -1230 3750 -1230 {lab=#net24}
N 3750 -1230 3760 -1230 {lab=#net24}
N 3830 -2640 3830 -2630 {lab=GND}
N 3790 -2760 3830 -2760 {lab=#net25}
N 3790 -2790 3790 -2760 {lab=#net25}
N 3790 -2760 3790 -2730 {lab=#net25}
N 3830 -2260 3830 -2250 {lab=GND}
N 3790 -2380 3830 -2380 {lab=#net26}
N 3790 -2410 3790 -2380 {lab=#net26}
N 3790 -2380 3790 -2350 {lab=#net26}
N 3830 -1880 3830 -1870 {lab=GND}
N 3790 -2000 3830 -2000 {lab=#net27}
N 3790 -2030 3790 -2000 {lab=#net27}
N 3790 -2000 3790 -1970 {lab=#net27}
N 3830 -1500 3830 -1490 {lab=GND}
N 3790 -1620 3830 -1620 {lab=#net28}
N 3790 -1650 3790 -1620 {lab=#net28}
N 3790 -1620 3790 -1590 {lab=#net28}
N 3830 -1110 3830 -1100 {lab=GND}
N 3790 -1230 3830 -1230 {lab=#net29}
N 3790 -1260 3790 -1230 {lab=#net29}
N 3790 -1230 3790 -1200 {lab=#net29}
N 3760 -1140 3790 -1140 {lab=#net24}
N 3760 -1320 3760 -1140 {lab=#net24}
N 3760 -1320 3790 -1320 {lab=#net24}
N 3760 -1530 3790 -1530 {lab=#net23}
N 3760 -1710 3760 -1530 {lab=#net23}
N 3760 -1710 3790 -1710 {lab=#net23}
N 3760 -2090 3790 -2090 {lab=#net22}
N 3760 -2090 3760 -1910 {lab=#net22}
N 3760 -1910 3790 -1910 {lab=#net22}
N 3760 -2290 3790 -2290 {lab=#net21}
N 3760 -2470 3760 -2290 {lab=#net21}
N 3760 -2470 3790 -2470 {lab=#net21}
N 3760 -2850 3790 -2850 {lab=#net20}
N 3760 -2850 3760 -2670 {lab=#net20}
N 3760 -2670 3790 -2670 {lab=#net20}
N 3790 -1230 3830 -1230 {lab=#net29}
N 3830 -1350 4090 -1350 {lab=VDD}
N 3830 -1230 4090 -1230 {lab=#net29}
N 4090 -1290 4090 -1230 {lab=#net29}
N 4090 -1230 4090 -1170 {lab=#net29}
N 3830 -1110 4090 -1110 {lab=GND}
N 4130 -1140 4130 -1080 {lab=#net24}
N 3760 -1080 4130 -1080 {lab=#net24}
N 3760 -1140 3760 -1080 {lab=#net24}
N 4130 -1430 4130 -1320 {lab=#net24}
N 3760 -1430 4130 -1430 {lab=#net24}
N 3760 -1430 3760 -1320 {lab=#net24}
N 3790 -2760 3830 -2760 {lab=#net25}
N 3830 -2880 4090 -2880 {lab=VDD}
N 3830 -2760 4090 -2760 {lab=#net25}
N 4090 -2820 4090 -2760 {lab=#net25}
N 4090 -2760 4090 -2700 {lab=#net25}
N 3830 -2640 4090 -2640 {lab=GND}
N 4130 -2670 4130 -2610 {lab=#net20}
N 3760 -2610 4130 -2610 {lab=#net20}
N 3760 -2670 3760 -2610 {lab=#net20}
N 4130 -2960 4130 -2850 {lab=#net20}
N 3760 -2960 4130 -2960 {lab=#net20}
N 3760 -2960 3760 -2850 {lab=#net20}
N 3790 -2380 3830 -2380 {lab=#net26}
N 3830 -2500 4090 -2500 {lab=VDD}
N 3830 -2380 4090 -2380 {lab=#net26}
N 4090 -2440 4090 -2380 {lab=#net26}
N 4090 -2380 4090 -2320 {lab=#net26}
N 3830 -2260 4090 -2260 {lab=GND}
N 4130 -2290 4130 -2230 {lab=#net21}
N 3760 -2230 4130 -2230 {lab=#net21}
N 3760 -2290 3760 -2230 {lab=#net21}
N 4130 -2580 4130 -2470 {lab=#net21}
N 3760 -2580 4130 -2580 {lab=#net21}
N 3760 -2580 3760 -2470 {lab=#net21}
N 3790 -2000 3830 -2000 {lab=#net27}
N 3830 -2120 4090 -2120 {lab=VDD}
N 3830 -2000 4090 -2000 {lab=#net27}
N 4090 -2060 4090 -2000 {lab=#net27}
N 4090 -2000 4090 -1940 {lab=#net27}
N 3830 -1880 4090 -1880 {lab=GND}
N 4130 -1910 4130 -1850 {lab=#net22}
N 3760 -1850 4130 -1850 {lab=#net22}
N 3760 -1910 3760 -1850 {lab=#net22}
N 4130 -2200 4130 -2090 {lab=#net22}
N 3760 -2200 4130 -2200 {lab=#net22}
N 3760 -2200 3760 -2090 {lab=#net22}
N 3790 -1620 3830 -1620 {lab=#net28}
N 3830 -1740 4090 -1740 {lab=VDD}
N 4090 -1680 4090 -1620 {lab=#net28}
N 4090 -1620 4090 -1560 {lab=#net28}
N 3830 -1500 4090 -1500 {lab=GND}
N 4130 -1530 4130 -1470 {lab=#net23}
N 3760 -1470 4130 -1470 {lab=#net23}
N 3760 -1530 3760 -1470 {lab=#net23}
N 4130 -1820 4130 -1710 {lab=#net23}
N 3760 -1820 4130 -1820 {lab=#net23}
N 3760 -1820 3760 -1710 {lab=#net23}
N 4090 -2760 4170 -2760 {lab=#net25}
N 3830 -2940 3830 -2880 {lab=VDD}
N 3830 -2560 3830 -2500 {lab=VDD}
N 4090 -2380 4170 -2380 {lab=#net26}
N 3830 -2180 3830 -2120 {lab=VDD}
N 3830 -1800 3830 -1740 {lab=VDD}
N 4090 -2000 4170 -2000 {lab=#net27}
N 4090 -1620 4170 -1620 {lab=#net28}
N 3830 -1410 3830 -1350 {lab=VDD}
N 4090 -1230 4160 -1230 {lab=#net29}
N 4160 -1230 4170 -1230 {lab=#net29}
N 4240 -2640 4240 -2630 {lab=GND}
N 4200 -2760 4240 -2760 {lab=#net30}
N 4200 -2790 4200 -2760 {lab=#net30}
N 4200 -2760 4200 -2730 {lab=#net30}
N 4240 -2260 4240 -2250 {lab=GND}
N 4200 -2380 4240 -2380 {lab=#net31}
N 4200 -2410 4200 -2380 {lab=#net31}
N 4200 -2380 4200 -2350 {lab=#net31}
N 4240 -1880 4240 -1870 {lab=GND}
N 4200 -2000 4240 -2000 {lab=#net32}
N 4200 -2030 4200 -2000 {lab=#net32}
N 4200 -2000 4200 -1970 {lab=#net32}
N 4240 -1500 4240 -1490 {lab=GND}
N 4200 -1620 4240 -1620 {lab=#net33}
N 4200 -1650 4200 -1620 {lab=#net33}
N 4200 -1620 4200 -1590 {lab=#net33}
N 4240 -1110 4240 -1100 {lab=GND}
N 4200 -1230 4240 -1230 {lab=#net34}
N 4200 -1260 4200 -1230 {lab=#net34}
N 4200 -1230 4200 -1200 {lab=#net34}
N 4170 -1140 4200 -1140 {lab=#net29}
N 4170 -1320 4170 -1140 {lab=#net29}
N 4170 -1320 4200 -1320 {lab=#net29}
N 4170 -1530 4200 -1530 {lab=#net28}
N 4170 -1710 4170 -1530 {lab=#net28}
N 4170 -1710 4200 -1710 {lab=#net28}
N 4170 -2090 4200 -2090 {lab=#net27}
N 4170 -2090 4170 -1910 {lab=#net27}
N 4170 -1910 4200 -1910 {lab=#net27}
N 4170 -2290 4200 -2290 {lab=#net26}
N 4170 -2470 4170 -2290 {lab=#net26}
N 4170 -2470 4200 -2470 {lab=#net26}
N 4170 -2850 4200 -2850 {lab=#net25}
N 4170 -2850 4170 -2670 {lab=#net25}
N 4170 -2670 4200 -2670 {lab=#net25}
N 4200 -1230 4240 -1230 {lab=#net34}
N 4240 -1350 4500 -1350 {lab=VDD}
N 4240 -1230 4500 -1230 {lab=#net34}
N 4500 -1290 4500 -1230 {lab=#net34}
N 4500 -1230 4500 -1170 {lab=#net34}
N 4240 -1110 4500 -1110 {lab=GND}
N 4540 -1140 4540 -1080 {lab=#net29}
N 4170 -1080 4540 -1080 {lab=#net29}
N 4170 -1140 4170 -1080 {lab=#net29}
N 4540 -1430 4540 -1320 {lab=#net29}
N 4170 -1430 4540 -1430 {lab=#net29}
N 4170 -1430 4170 -1320 {lab=#net29}
N 4200 -2760 4240 -2760 {lab=#net30}
N 4240 -2880 4500 -2880 {lab=VDD}
N 4240 -2760 4500 -2760 {lab=#net30}
N 4500 -2820 4500 -2760 {lab=#net30}
N 4500 -2760 4500 -2700 {lab=#net30}
N 4240 -2640 4500 -2640 {lab=GND}
N 4540 -2670 4540 -2610 {lab=#net25}
N 4170 -2610 4540 -2610 {lab=#net25}
N 4170 -2670 4170 -2610 {lab=#net25}
N 4540 -2960 4540 -2850 {lab=#net25}
N 4170 -2960 4540 -2960 {lab=#net25}
N 4170 -2960 4170 -2850 {lab=#net25}
N 4200 -2380 4240 -2380 {lab=#net31}
N 4240 -2500 4500 -2500 {lab=VDD}
N 4240 -2380 4500 -2380 {lab=#net31}
N 4500 -2440 4500 -2380 {lab=#net31}
N 4500 -2380 4500 -2320 {lab=#net31}
N 4240 -2260 4500 -2260 {lab=GND}
N 4540 -2290 4540 -2230 {lab=#net26}
N 4170 -2230 4540 -2230 {lab=#net26}
N 4170 -2290 4170 -2230 {lab=#net26}
N 4540 -2580 4540 -2470 {lab=#net26}
N 4170 -2580 4540 -2580 {lab=#net26}
N 4170 -2580 4170 -2470 {lab=#net26}
N 4200 -2000 4240 -2000 {lab=#net32}
N 4240 -2120 4500 -2120 {lab=VDD}
N 4240 -2000 4500 -2000 {lab=#net32}
N 4500 -2060 4500 -2000 {lab=#net32}
N 4500 -2000 4500 -1940 {lab=#net32}
N 4240 -1880 4500 -1880 {lab=GND}
N 4540 -1910 4540 -1850 {lab=#net27}
N 4170 -1850 4540 -1850 {lab=#net27}
N 4170 -1910 4170 -1850 {lab=#net27}
N 4540 -2200 4540 -2090 {lab=#net27}
N 4170 -2200 4540 -2200 {lab=#net27}
N 4170 -2200 4170 -2090 {lab=#net27}
N 4200 -1620 4240 -1620 {lab=#net33}
N 4240 -1740 4500 -1740 {lab=VDD}
N 4500 -1680 4500 -1620 {lab=#net33}
N 4500 -1620 4500 -1560 {lab=#net33}
N 4240 -1500 4500 -1500 {lab=GND}
N 4540 -1530 4540 -1470 {lab=#net28}
N 4170 -1470 4540 -1470 {lab=#net28}
N 4170 -1530 4170 -1470 {lab=#net28}
N 4540 -1820 4540 -1710 {lab=#net28}
N 4170 -1820 4540 -1820 {lab=#net28}
N 4170 -1820 4170 -1710 {lab=#net28}
N 4500 -2760 4580 -2760 {lab=#net30}
N 4240 -2940 4240 -2880 {lab=VDD}
N 4240 -2560 4240 -2500 {lab=VDD}
N 4500 -2380 4580 -2380 {lab=#net31}
N 4240 -2180 4240 -2120 {lab=VDD}
N 4240 -1800 4240 -1740 {lab=VDD}
N 4500 -2000 4580 -2000 {lab=#net32}
N 4500 -1620 4580 -1620 {lab=#net33}
N 4240 -1410 4240 -1350 {lab=VDD}
N 4500 -1230 4570 -1230 {lab=#net34}
N 4570 -1230 4580 -1230 {lab=#net34}
N 4650 -2640 4650 -2630 {lab=GND}
N 4610 -2760 4650 -2760 {lab=o5}
N 4610 -2790 4610 -2760 {lab=o5}
N 4610 -2760 4610 -2730 {lab=o5}
N 4650 -2260 4650 -2250 {lab=GND}
N 4610 -2380 4650 -2380 {lab=o6}
N 4610 -2410 4610 -2380 {lab=o6}
N 4610 -2380 4610 -2350 {lab=o6}
N 4650 -1880 4650 -1870 {lab=GND}
N 4610 -2000 4650 -2000 {lab=o7}
N 4610 -2030 4610 -2000 {lab=o7}
N 4610 -2000 4610 -1970 {lab=o7}
N 4650 -1500 4650 -1490 {lab=GND}
N 4610 -1620 4650 -1620 {lab=o8}
N 4610 -1650 4610 -1620 {lab=o8}
N 4610 -1620 4610 -1590 {lab=o8}
N 4650 -1110 4650 -1100 {lab=GND}
N 4610 -1230 4650 -1230 {lab=o9}
N 4610 -1260 4610 -1230 {lab=o9}
N 4610 -1230 4610 -1200 {lab=o9}
N 4580 -1140 4610 -1140 {lab=#net34}
N 4580 -1320 4580 -1140 {lab=#net34}
N 4580 -1320 4610 -1320 {lab=#net34}
N 4580 -1530 4610 -1530 {lab=#net33}
N 4580 -1710 4580 -1530 {lab=#net33}
N 4580 -1710 4610 -1710 {lab=#net33}
N 4580 -2090 4610 -2090 {lab=#net32}
N 4580 -2090 4580 -1910 {lab=#net32}
N 4580 -1910 4610 -1910 {lab=#net32}
N 4580 -2290 4610 -2290 {lab=#net31}
N 4580 -2470 4580 -2290 {lab=#net31}
N 4580 -2470 4610 -2470 {lab=#net31}
N 4580 -2850 4610 -2850 {lab=#net30}
N 4580 -2850 4580 -2670 {lab=#net30}
N 4580 -2670 4610 -2670 {lab=#net30}
N 4610 -1230 4650 -1230 {lab=o9}
N 4650 -1350 4910 -1350 {lab=VDD}
N 4650 -1230 4910 -1230 {lab=o9}
N 4910 -1290 4910 -1230 {lab=o9}
N 4910 -1230 4910 -1170 {lab=o9}
N 4650 -1110 4910 -1110 {lab=GND}
N 4950 -1140 4950 -1080 {lab=#net34}
N 4580 -1080 4950 -1080 {lab=#net34}
N 4580 -1140 4580 -1080 {lab=#net34}
N 4950 -1430 4950 -1320 {lab=#net34}
N 4580 -1430 4950 -1430 {lab=#net34}
N 4580 -1430 4580 -1320 {lab=#net34}
N 4610 -2760 4650 -2760 {lab=o5}
N 4650 -2880 4910 -2880 {lab=VDD}
N 4650 -2760 4910 -2760 {lab=o5}
N 4910 -2820 4910 -2760 {lab=o5}
N 4910 -2760 4910 -2700 {lab=o5}
N 4650 -2640 4910 -2640 {lab=GND}
N 4950 -2670 4950 -2610 {lab=#net30}
N 4580 -2610 4950 -2610 {lab=#net30}
N 4580 -2670 4580 -2610 {lab=#net30}
N 4950 -2960 4950 -2850 {lab=#net30}
N 4580 -2960 4950 -2960 {lab=#net30}
N 4580 -2960 4580 -2850 {lab=#net30}
N 4610 -2380 4650 -2380 {lab=o6}
N 4650 -2500 4910 -2500 {lab=VDD}
N 4650 -2380 4910 -2380 {lab=o6}
N 4910 -2440 4910 -2380 {lab=o6}
N 4910 -2380 4910 -2320 {lab=o6}
N 4650 -2260 4910 -2260 {lab=GND}
N 4950 -2290 4950 -2230 {lab=#net31}
N 4580 -2230 4950 -2230 {lab=#net31}
N 4580 -2290 4580 -2230 {lab=#net31}
N 4950 -2580 4950 -2470 {lab=#net31}
N 4580 -2580 4950 -2580 {lab=#net31}
N 4580 -2580 4580 -2470 {lab=#net31}
N 4610 -2000 4650 -2000 {lab=o7}
N 4650 -2120 4910 -2120 {lab=VDD}
N 4650 -2000 4910 -2000 {lab=o7}
N 4910 -2060 4910 -2000 {lab=o7}
N 4910 -2000 4910 -1940 {lab=o7}
N 4650 -1880 4910 -1880 {lab=GND}
N 4950 -1910 4950 -1850 {lab=#net32}
N 4580 -1850 4950 -1850 {lab=#net32}
N 4580 -1910 4580 -1850 {lab=#net32}
N 4950 -2200 4950 -2090 {lab=#net32}
N 4580 -2200 4950 -2200 {lab=#net32}
N 4580 -2200 4580 -2090 {lab=#net32}
N 4610 -1620 4650 -1620 {lab=o8}
N 4650 -1740 4910 -1740 {lab=VDD}
N 4910 -1680 4910 -1620 {lab=o8}
N 4910 -1620 4910 -1560 {lab=o8}
N 4650 -1500 4910 -1500 {lab=GND}
N 4950 -1530 4950 -1470 {lab=#net33}
N 4580 -1470 4950 -1470 {lab=#net33}
N 4580 -1530 4580 -1470 {lab=#net33}
N 4950 -1820 4950 -1710 {lab=#net33}
N 4580 -1820 4950 -1820 {lab=#net33}
N 4580 -1820 4580 -1710 {lab=#net33}
N 4910 -2760 4990 -2760 {lab=o5}
N 4650 -2940 4650 -2880 {lab=VDD}
N 4650 -2560 4650 -2500 {lab=VDD}
N 4910 -2380 4990 -2380 {lab=o6}
N 4650 -2180 4650 -2120 {lab=VDD}
N 4650 -1800 4650 -1740 {lab=VDD}
N 4910 -2000 4990 -2000 {lab=o7}
N 4910 -1620 4990 -1620 {lab=o8}
N 4650 -1410 4650 -1350 {lab=VDD}
N 4910 -1230 4980 -1230 {lab=o9}
N 4980 -1230 4990 -1230 {lab=o9}
N 3420 -1620 3680 -1620 {lab=#net23}
N 3830 -1620 4090 -1620 {lab=#net28}
N 4240 -1620 4500 -1620 {lab=#net33}
N 4650 -1620 4910 -1620 {lab=o8}
N 2510 -5000 2510 -4990 {lab=GND}
N 2470 -5120 2510 -5120 {lab=#net35}
N 2470 -5150 2470 -5120 {lab=#net35}
N 2470 -5120 2470 -5090 {lab=#net35}
N 2510 -4620 2510 -4610 {lab=GND}
N 2470 -4740 2510 -4740 {lab=#net36}
N 2470 -4770 2470 -4740 {lab=#net36}
N 2470 -4740 2470 -4710 {lab=#net36}
N 2510 -4240 2510 -4230 {lab=GND}
N 2470 -4360 2510 -4360 {lab=#net37}
N 2470 -4390 2470 -4360 {lab=#net37}
N 2470 -4360 2470 -4330 {lab=#net37}
N 2510 -3860 2510 -3850 {lab=GND}
N 2470 -3980 2510 -3980 {lab=#net38}
N 2470 -4010 2470 -3980 {lab=#net38}
N 2470 -3980 2470 -3950 {lab=#net38}
N 2510 -3470 2510 -3460 {lab=GND}
N 2470 -3590 2510 -3590 {lab=#net39}
N 2470 -3620 2470 -3590 {lab=#net39}
N 2470 -3590 2470 -3560 {lab=#net39}
N 2440 -3500 2470 -3500 {lab=ind}
N 2440 -3680 2440 -3500 {lab=ind}
N 2440 -3680 2470 -3680 {lab=ind}
N 2440 -3890 2470 -3890 {lab=ind}
N 2440 -4070 2440 -3890 {lab=ind}
N 2440 -4070 2470 -4070 {lab=ind}
N 2440 -4450 2470 -4450 {lab=ind}
N 2440 -4450 2440 -4270 {lab=ind}
N 2440 -4270 2470 -4270 {lab=ind}
N 2440 -4650 2470 -4650 {lab=ind}
N 2440 -4830 2440 -4650 {lab=ind}
N 2440 -4830 2470 -4830 {lab=ind}
N 2440 -5210 2470 -5210 {lab=ind}
N 2440 -5210 2440 -5030 {lab=ind}
N 2440 -5030 2470 -5030 {lab=ind}
N 2470 -3590 2510 -3590 {lab=#net39}
N 2510 -3710 2770 -3710 {lab=#net40}
N 2510 -3590 2770 -3590 {lab=#net39}
N 2770 -3650 2770 -3590 {lab=#net39}
N 2770 -3590 2770 -3530 {lab=#net39}
N 2510 -3470 2770 -3470 {lab=GND}
N 2810 -3500 2810 -3440 {lab=ind}
N 2440 -3440 2810 -3440 {lab=ind}
N 2440 -3500 2440 -3440 {lab=ind}
N 2810 -3790 2810 -3680 {lab=ind}
N 2440 -3790 2810 -3790 {lab=ind}
N 2440 -3790 2440 -3680 {lab=ind}
N 2470 -5120 2510 -5120 {lab=#net35}
N 2510 -5240 2770 -5240 {lab=#net41}
N 2510 -5120 2770 -5120 {lab=#net35}
N 2770 -5180 2770 -5120 {lab=#net35}
N 2770 -5120 2770 -5060 {lab=#net35}
N 2510 -5000 2770 -5000 {lab=GND}
N 2810 -5030 2810 -4970 {lab=ind}
N 2440 -4970 2810 -4970 {lab=ind}
N 2440 -5030 2440 -4970 {lab=ind}
N 2810 -5320 2810 -5210 {lab=ind}
N 2440 -5320 2810 -5320 {lab=ind}
N 2440 -5320 2440 -5210 {lab=ind}
N 2470 -4740 2510 -4740 {lab=#net36}
N 2510 -4860 2770 -4860 {lab=#net42}
N 2510 -4740 2770 -4740 {lab=#net36}
N 2770 -4800 2770 -4740 {lab=#net36}
N 2770 -4740 2770 -4680 {lab=#net36}
N 2510 -4620 2770 -4620 {lab=GND}
N 2810 -4650 2810 -4590 {lab=ind}
N 2440 -4590 2810 -4590 {lab=ind}
N 2440 -4650 2440 -4590 {lab=ind}
N 2810 -4940 2810 -4830 {lab=ind}
N 2440 -4940 2810 -4940 {lab=ind}
N 2440 -4940 2440 -4830 {lab=ind}
N 2470 -4360 2510 -4360 {lab=#net37}
N 2510 -4480 2770 -4480 {lab=#net43}
N 2510 -4360 2770 -4360 {lab=#net37}
N 2770 -4420 2770 -4360 {lab=#net37}
N 2770 -4360 2770 -4300 {lab=#net37}
N 2510 -4240 2770 -4240 {lab=GND}
N 2810 -4270 2810 -4210 {lab=ind}
N 2440 -4210 2810 -4210 {lab=ind}
N 2440 -4270 2440 -4210 {lab=ind}
N 2810 -4560 2810 -4450 {lab=ind}
N 2440 -4560 2810 -4560 {lab=ind}
N 2440 -4560 2440 -4450 {lab=ind}
N 2470 -3980 2510 -3980 {lab=#net38}
N 2510 -4100 2770 -4100 {lab=#net44}
N 2510 -3980 2770 -3980 {lab=#net38}
N 2770 -4040 2770 -3980 {lab=#net38}
N 2770 -3980 2770 -3920 {lab=#net38}
N 2510 -3860 2770 -3860 {lab=GND}
N 2810 -3890 2810 -3830 {lab=ind}
N 2440 -3830 2810 -3830 {lab=ind}
N 2440 -3890 2440 -3830 {lab=ind}
N 2810 -4180 2810 -4070 {lab=ind}
N 2440 -4180 2810 -4180 {lab=ind}
N 2440 -4180 2440 -4070 {lab=ind}
N 2770 -5120 2850 -5120 {lab=#net35}
N 2770 -4740 2850 -4740 {lab=#net36}
N 2770 -4360 2850 -4360 {lab=#net37}
N 2770 -3980 2850 -3980 {lab=#net38}
N 2770 -3590 2840 -3590 {lab=#net39}
N 2840 -3590 2850 -3590 {lab=#net39}
N 2920 -5000 2920 -4990 {lab=GND}
N 2880 -5120 2920 -5120 {lab=#net45}
N 2880 -5150 2880 -5120 {lab=#net45}
N 2880 -5120 2880 -5090 {lab=#net45}
N 2920 -4620 2920 -4610 {lab=GND}
N 2880 -4740 2920 -4740 {lab=#net46}
N 2880 -4770 2880 -4740 {lab=#net46}
N 2880 -4740 2880 -4710 {lab=#net46}
N 2920 -4240 2920 -4230 {lab=GND}
N 2880 -4360 2920 -4360 {lab=#net47}
N 2880 -4390 2880 -4360 {lab=#net47}
N 2880 -4360 2880 -4330 {lab=#net47}
N 2920 -3860 2920 -3850 {lab=GND}
N 2880 -3980 2920 -3980 {lab=#net48}
N 2880 -4010 2880 -3980 {lab=#net48}
N 2880 -3980 2880 -3950 {lab=#net48}
N 2920 -3470 2920 -3460 {lab=GND}
N 2880 -3590 2920 -3590 {lab=#net49}
N 2880 -3620 2880 -3590 {lab=#net49}
N 2880 -3590 2880 -3560 {lab=#net49}
N 2850 -3500 2880 -3500 {lab=#net39}
N 2850 -3680 2850 -3500 {lab=#net39}
N 2850 -3680 2880 -3680 {lab=#net39}
N 2850 -3890 2880 -3890 {lab=#net38}
N 2850 -4070 2850 -3890 {lab=#net38}
N 2850 -4070 2880 -4070 {lab=#net38}
N 2850 -4450 2880 -4450 {lab=#net37}
N 2850 -4450 2850 -4270 {lab=#net37}
N 2850 -4270 2880 -4270 {lab=#net37}
N 2850 -4650 2880 -4650 {lab=#net36}
N 2850 -4830 2850 -4650 {lab=#net36}
N 2850 -4830 2880 -4830 {lab=#net36}
N 2850 -5210 2880 -5210 {lab=#net35}
N 2850 -5210 2850 -5030 {lab=#net35}
N 2850 -5030 2880 -5030 {lab=#net35}
N 2880 -3590 2920 -3590 {lab=#net49}
N 2920 -3710 3180 -3710 {lab=VDD}
N 2920 -3590 3180 -3590 {lab=#net49}
N 3180 -3650 3180 -3590 {lab=#net49}
N 3180 -3590 3180 -3530 {lab=#net49}
N 2920 -3470 3180 -3470 {lab=GND}
N 3220 -3500 3220 -3440 {lab=#net39}
N 2850 -3440 3220 -3440 {lab=#net39}
N 2850 -3500 2850 -3440 {lab=#net39}
N 3220 -3790 3220 -3680 {lab=#net39}
N 2850 -3790 3220 -3790 {lab=#net39}
N 2850 -3790 2850 -3680 {lab=#net39}
N 2880 -5120 2920 -5120 {lab=#net45}
N 2920 -5240 3180 -5240 {lab=VDD}
N 2920 -5120 3180 -5120 {lab=#net45}
N 3180 -5180 3180 -5120 {lab=#net45}
N 3180 -5120 3180 -5060 {lab=#net45}
N 2920 -5000 3180 -5000 {lab=GND}
N 3220 -5030 3220 -4970 {lab=#net35}
N 2850 -4970 3220 -4970 {lab=#net35}
N 2850 -5030 2850 -4970 {lab=#net35}
N 3220 -5320 3220 -5210 {lab=#net35}
N 2850 -5320 3220 -5320 {lab=#net35}
N 2850 -5320 2850 -5210 {lab=#net35}
N 2880 -4740 2920 -4740 {lab=#net46}
N 2920 -4860 3180 -4860 {lab=VDD}
N 2920 -4740 3180 -4740 {lab=#net46}
N 3180 -4800 3180 -4740 {lab=#net46}
N 3180 -4740 3180 -4680 {lab=#net46}
N 2920 -4620 3180 -4620 {lab=GND}
N 3220 -4650 3220 -4590 {lab=#net36}
N 2850 -4590 3220 -4590 {lab=#net36}
N 2850 -4650 2850 -4590 {lab=#net36}
N 3220 -4940 3220 -4830 {lab=#net36}
N 2850 -4940 3220 -4940 {lab=#net36}
N 2850 -4940 2850 -4830 {lab=#net36}
N 2880 -4360 2920 -4360 {lab=#net47}
N 2920 -4480 3180 -4480 {lab=VDD}
N 2920 -4360 3180 -4360 {lab=#net47}
N 3180 -4420 3180 -4360 {lab=#net47}
N 3180 -4360 3180 -4300 {lab=#net47}
N 2920 -4240 3180 -4240 {lab=GND}
N 3220 -4270 3220 -4210 {lab=#net37}
N 2850 -4210 3220 -4210 {lab=#net37}
N 2850 -4270 2850 -4210 {lab=#net37}
N 3220 -4560 3220 -4450 {lab=#net37}
N 2850 -4560 3220 -4560 {lab=#net37}
N 2850 -4560 2850 -4450 {lab=#net37}
N 2880 -3980 2920 -3980 {lab=#net48}
N 2920 -4100 3180 -4100 {lab=VDD}
N 3180 -4040 3180 -3980 {lab=#net48}
N 3180 -3980 3180 -3920 {lab=#net48}
N 2920 -3860 3180 -3860 {lab=GND}
N 3220 -3890 3220 -3830 {lab=#net38}
N 2850 -3830 3220 -3830 {lab=#net38}
N 2850 -3890 2850 -3830 {lab=#net38}
N 3220 -4180 3220 -4070 {lab=#net38}
N 2850 -4180 3220 -4180 {lab=#net38}
N 2850 -4180 2850 -4070 {lab=#net38}
N 3180 -5120 3260 -5120 {lab=#net45}
N 2920 -5300 2920 -5240 {lab=VDD}
N 2920 -4920 2920 -4860 {lab=VDD}
N 3180 -4740 3260 -4740 {lab=#net46}
N 2920 -4540 2920 -4480 {lab=VDD}
N 2920 -4160 2920 -4100 {lab=VDD}
N 3180 -4360 3260 -4360 {lab=#net47}
N 3180 -3980 3260 -3980 {lab=#net48}
N 2920 -3770 2920 -3710 {lab=VDD}
N 3180 -3590 3250 -3590 {lab=#net49}
N 3250 -3590 3260 -3590 {lab=#net49}
N 3330 -5000 3330 -4990 {lab=GND}
N 3290 -5120 3330 -5120 {lab=#net50}
N 3290 -5150 3290 -5120 {lab=#net50}
N 3290 -5120 3290 -5090 {lab=#net50}
N 3330 -4620 3330 -4610 {lab=GND}
N 3290 -4740 3330 -4740 {lab=#net51}
N 3290 -4770 3290 -4740 {lab=#net51}
N 3290 -4740 3290 -4710 {lab=#net51}
N 3330 -4240 3330 -4230 {lab=GND}
N 3290 -4360 3330 -4360 {lab=#net52}
N 3290 -4390 3290 -4360 {lab=#net52}
N 3290 -4360 3290 -4330 {lab=#net52}
N 3330 -3860 3330 -3850 {lab=GND}
N 3290 -3980 3330 -3980 {lab=#net53}
N 3290 -4010 3290 -3980 {lab=#net53}
N 3290 -3980 3290 -3950 {lab=#net53}
N 3330 -3470 3330 -3460 {lab=GND}
N 3290 -3590 3330 -3590 {lab=#net54}
N 3290 -3620 3290 -3590 {lab=#net54}
N 3290 -3590 3290 -3560 {lab=#net54}
N 3260 -3500 3290 -3500 {lab=#net49}
N 3260 -3680 3260 -3500 {lab=#net49}
N 3260 -3680 3290 -3680 {lab=#net49}
N 3260 -3890 3290 -3890 {lab=#net48}
N 3260 -4070 3260 -3890 {lab=#net48}
N 3260 -4070 3290 -4070 {lab=#net48}
N 3260 -4450 3290 -4450 {lab=#net47}
N 3260 -4450 3260 -4270 {lab=#net47}
N 3260 -4270 3290 -4270 {lab=#net47}
N 3260 -4650 3290 -4650 {lab=#net46}
N 3260 -4830 3260 -4650 {lab=#net46}
N 3260 -4830 3290 -4830 {lab=#net46}
N 3260 -5210 3290 -5210 {lab=#net45}
N 3260 -5210 3260 -5030 {lab=#net45}
N 3260 -5030 3290 -5030 {lab=#net45}
N 3290 -3590 3330 -3590 {lab=#net54}
N 3330 -3710 3590 -3710 {lab=VDD}
N 3330 -3590 3590 -3590 {lab=#net54}
N 3590 -3650 3590 -3590 {lab=#net54}
N 3590 -3590 3590 -3530 {lab=#net54}
N 3330 -3470 3590 -3470 {lab=GND}
N 3630 -3500 3630 -3440 {lab=#net49}
N 3260 -3440 3630 -3440 {lab=#net49}
N 3260 -3500 3260 -3440 {lab=#net49}
N 3630 -3790 3630 -3680 {lab=#net49}
N 3260 -3790 3630 -3790 {lab=#net49}
N 3260 -3790 3260 -3680 {lab=#net49}
N 3290 -5120 3330 -5120 {lab=#net50}
N 3330 -5240 3590 -5240 {lab=VDD}
N 3330 -5120 3590 -5120 {lab=#net50}
N 3590 -5180 3590 -5120 {lab=#net50}
N 3590 -5120 3590 -5060 {lab=#net50}
N 3330 -5000 3590 -5000 {lab=GND}
N 3630 -5030 3630 -4970 {lab=#net45}
N 3260 -4970 3630 -4970 {lab=#net45}
N 3260 -5030 3260 -4970 {lab=#net45}
N 3630 -5320 3630 -5210 {lab=#net45}
N 3260 -5320 3630 -5320 {lab=#net45}
N 3260 -5320 3260 -5210 {lab=#net45}
N 3290 -4740 3330 -4740 {lab=#net51}
N 3330 -4860 3590 -4860 {lab=VDD}
N 3330 -4740 3590 -4740 {lab=#net51}
N 3590 -4800 3590 -4740 {lab=#net51}
N 3590 -4740 3590 -4680 {lab=#net51}
N 3330 -4620 3590 -4620 {lab=GND}
N 3630 -4650 3630 -4590 {lab=#net46}
N 3260 -4590 3630 -4590 {lab=#net46}
N 3260 -4650 3260 -4590 {lab=#net46}
N 3630 -4940 3630 -4830 {lab=#net46}
N 3260 -4940 3630 -4940 {lab=#net46}
N 3260 -4940 3260 -4830 {lab=#net46}
N 3290 -4360 3330 -4360 {lab=#net52}
N 3330 -4480 3590 -4480 {lab=VDD}
N 3330 -4360 3590 -4360 {lab=#net52}
N 3590 -4420 3590 -4360 {lab=#net52}
N 3590 -4360 3590 -4300 {lab=#net52}
N 3330 -4240 3590 -4240 {lab=GND}
N 3630 -4270 3630 -4210 {lab=#net47}
N 3260 -4210 3630 -4210 {lab=#net47}
N 3260 -4270 3260 -4210 {lab=#net47}
N 3630 -4560 3630 -4450 {lab=#net47}
N 3260 -4560 3630 -4560 {lab=#net47}
N 3260 -4560 3260 -4450 {lab=#net47}
N 3290 -3980 3330 -3980 {lab=#net53}
N 3330 -4100 3590 -4100 {lab=VDD}
N 3590 -4040 3590 -3980 {lab=#net53}
N 3590 -3980 3590 -3920 {lab=#net53}
N 3330 -3860 3590 -3860 {lab=GND}
N 3630 -3890 3630 -3830 {lab=#net48}
N 3260 -3830 3630 -3830 {lab=#net48}
N 3260 -3890 3260 -3830 {lab=#net48}
N 3630 -4180 3630 -4070 {lab=#net48}
N 3260 -4180 3630 -4180 {lab=#net48}
N 3260 -4180 3260 -4070 {lab=#net48}
N 3590 -5120 3670 -5120 {lab=#net50}
N 3330 -5300 3330 -5240 {lab=VDD}
N 3330 -4920 3330 -4860 {lab=VDD}
N 3590 -4740 3670 -4740 {lab=#net51}
N 3330 -4540 3330 -4480 {lab=VDD}
N 3330 -4160 3330 -4100 {lab=VDD}
N 3590 -4360 3670 -4360 {lab=#net52}
N 3590 -3980 3670 -3980 {lab=#net53}
N 3330 -3770 3330 -3710 {lab=VDD}
N 3590 -3590 3660 -3590 {lab=#net54}
N 3660 -3590 3670 -3590 {lab=#net54}
N 3740 -5000 3740 -4990 {lab=GND}
N 3700 -5120 3740 -5120 {lab=#net55}
N 3700 -5150 3700 -5120 {lab=#net55}
N 3700 -5120 3700 -5090 {lab=#net55}
N 3740 -4620 3740 -4610 {lab=GND}
N 3700 -4740 3740 -4740 {lab=#net56}
N 3700 -4770 3700 -4740 {lab=#net56}
N 3700 -4740 3700 -4710 {lab=#net56}
N 3740 -4240 3740 -4230 {lab=GND}
N 3700 -4360 3740 -4360 {lab=#net57}
N 3700 -4390 3700 -4360 {lab=#net57}
N 3700 -4360 3700 -4330 {lab=#net57}
N 3740 -3860 3740 -3850 {lab=GND}
N 3700 -3980 3740 -3980 {lab=#net58}
N 3700 -4010 3700 -3980 {lab=#net58}
N 3700 -3980 3700 -3950 {lab=#net58}
N 3740 -3470 3740 -3460 {lab=GND}
N 3700 -3590 3740 -3590 {lab=#net59}
N 3700 -3620 3700 -3590 {lab=#net59}
N 3700 -3590 3700 -3560 {lab=#net59}
N 3670 -3500 3700 -3500 {lab=#net54}
N 3670 -3680 3670 -3500 {lab=#net54}
N 3670 -3680 3700 -3680 {lab=#net54}
N 3670 -3890 3700 -3890 {lab=#net53}
N 3670 -4070 3670 -3890 {lab=#net53}
N 3670 -4070 3700 -4070 {lab=#net53}
N 3670 -4450 3700 -4450 {lab=#net52}
N 3670 -4450 3670 -4270 {lab=#net52}
N 3670 -4270 3700 -4270 {lab=#net52}
N 3670 -4650 3700 -4650 {lab=#net51}
N 3670 -4830 3670 -4650 {lab=#net51}
N 3670 -4830 3700 -4830 {lab=#net51}
N 3670 -5210 3700 -5210 {lab=#net50}
N 3670 -5210 3670 -5030 {lab=#net50}
N 3670 -5030 3700 -5030 {lab=#net50}
N 3700 -3590 3740 -3590 {lab=#net59}
N 3740 -3710 4000 -3710 {lab=VDD}
N 3740 -3590 4000 -3590 {lab=#net59}
N 4000 -3650 4000 -3590 {lab=#net59}
N 4000 -3590 4000 -3530 {lab=#net59}
N 3740 -3470 4000 -3470 {lab=GND}
N 4040 -3500 4040 -3440 {lab=#net54}
N 3670 -3440 4040 -3440 {lab=#net54}
N 3670 -3500 3670 -3440 {lab=#net54}
N 4040 -3790 4040 -3680 {lab=#net54}
N 3670 -3790 4040 -3790 {lab=#net54}
N 3670 -3790 3670 -3680 {lab=#net54}
N 3700 -5120 3740 -5120 {lab=#net55}
N 3740 -5240 4000 -5240 {lab=VDD}
N 3740 -5120 4000 -5120 {lab=#net55}
N 4000 -5180 4000 -5120 {lab=#net55}
N 4000 -5120 4000 -5060 {lab=#net55}
N 3740 -5000 4000 -5000 {lab=GND}
N 4040 -5030 4040 -4970 {lab=#net50}
N 3670 -4970 4040 -4970 {lab=#net50}
N 3670 -5030 3670 -4970 {lab=#net50}
N 4040 -5320 4040 -5210 {lab=#net50}
N 3670 -5320 4040 -5320 {lab=#net50}
N 3670 -5320 3670 -5210 {lab=#net50}
N 3700 -4740 3740 -4740 {lab=#net56}
N 3740 -4860 4000 -4860 {lab=VDD}
N 3740 -4740 4000 -4740 {lab=#net56}
N 4000 -4800 4000 -4740 {lab=#net56}
N 4000 -4740 4000 -4680 {lab=#net56}
N 3740 -4620 4000 -4620 {lab=GND}
N 4040 -4650 4040 -4590 {lab=#net51}
N 3670 -4590 4040 -4590 {lab=#net51}
N 3670 -4650 3670 -4590 {lab=#net51}
N 4040 -4940 4040 -4830 {lab=#net51}
N 3670 -4940 4040 -4940 {lab=#net51}
N 3670 -4940 3670 -4830 {lab=#net51}
N 3700 -4360 3740 -4360 {lab=#net57}
N 3740 -4480 4000 -4480 {lab=VDD}
N 3740 -4360 4000 -4360 {lab=#net57}
N 4000 -4420 4000 -4360 {lab=#net57}
N 4000 -4360 4000 -4300 {lab=#net57}
N 3740 -4240 4000 -4240 {lab=GND}
N 4040 -4270 4040 -4210 {lab=#net52}
N 3670 -4210 4040 -4210 {lab=#net52}
N 3670 -4270 3670 -4210 {lab=#net52}
N 4040 -4560 4040 -4450 {lab=#net52}
N 3670 -4560 4040 -4560 {lab=#net52}
N 3670 -4560 3670 -4450 {lab=#net52}
N 3700 -3980 3740 -3980 {lab=#net58}
N 3740 -4100 4000 -4100 {lab=VDD}
N 4000 -4040 4000 -3980 {lab=#net58}
N 4000 -3980 4000 -3920 {lab=#net58}
N 3740 -3860 4000 -3860 {lab=GND}
N 4040 -3890 4040 -3830 {lab=#net53}
N 3670 -3830 4040 -3830 {lab=#net53}
N 3670 -3890 3670 -3830 {lab=#net53}
N 4040 -4180 4040 -4070 {lab=#net53}
N 3670 -4180 4040 -4180 {lab=#net53}
N 3670 -4180 3670 -4070 {lab=#net53}
N 4000 -5120 4080 -5120 {lab=#net55}
N 3740 -5300 3740 -5240 {lab=VDD}
N 3740 -4920 3740 -4860 {lab=VDD}
N 4000 -4740 4080 -4740 {lab=#net56}
N 3740 -4540 3740 -4480 {lab=VDD}
N 3740 -4160 3740 -4100 {lab=VDD}
N 4000 -4360 4080 -4360 {lab=#net57}
N 4000 -3980 4080 -3980 {lab=#net58}
N 3740 -3770 3740 -3710 {lab=VDD}
N 4000 -3590 4070 -3590 {lab=#net59}
N 4070 -3590 4080 -3590 {lab=#net59}
N 4150 -5000 4150 -4990 {lab=GND}
N 4110 -5120 4150 -5120 {lab=#net60}
N 4110 -5150 4110 -5120 {lab=#net60}
N 4110 -5120 4110 -5090 {lab=#net60}
N 4150 -4620 4150 -4610 {lab=GND}
N 4110 -4740 4150 -4740 {lab=#net61}
N 4110 -4770 4110 -4740 {lab=#net61}
N 4110 -4740 4110 -4710 {lab=#net61}
N 4150 -4240 4150 -4230 {lab=GND}
N 4110 -4360 4150 -4360 {lab=#net62}
N 4110 -4390 4110 -4360 {lab=#net62}
N 4110 -4360 4110 -4330 {lab=#net62}
N 4150 -3860 4150 -3850 {lab=GND}
N 4110 -3980 4150 -3980 {lab=#net63}
N 4110 -4010 4110 -3980 {lab=#net63}
N 4110 -3980 4110 -3950 {lab=#net63}
N 4150 -3470 4150 -3460 {lab=GND}
N 4110 -3590 4150 -3590 {lab=#net64}
N 4110 -3620 4110 -3590 {lab=#net64}
N 4110 -3590 4110 -3560 {lab=#net64}
N 4080 -3500 4110 -3500 {lab=#net59}
N 4080 -3680 4080 -3500 {lab=#net59}
N 4080 -3680 4110 -3680 {lab=#net59}
N 4080 -3890 4110 -3890 {lab=#net58}
N 4080 -4070 4080 -3890 {lab=#net58}
N 4080 -4070 4110 -4070 {lab=#net58}
N 4080 -4450 4110 -4450 {lab=#net57}
N 4080 -4450 4080 -4270 {lab=#net57}
N 4080 -4270 4110 -4270 {lab=#net57}
N 4080 -4650 4110 -4650 {lab=#net56}
N 4080 -4830 4080 -4650 {lab=#net56}
N 4080 -4830 4110 -4830 {lab=#net56}
N 4080 -5210 4110 -5210 {lab=#net55}
N 4080 -5210 4080 -5030 {lab=#net55}
N 4080 -5030 4110 -5030 {lab=#net55}
N 4110 -3590 4150 -3590 {lab=#net64}
N 4150 -3710 4410 -3710 {lab=VDD}
N 4150 -3590 4410 -3590 {lab=#net64}
N 4410 -3650 4410 -3590 {lab=#net64}
N 4410 -3590 4410 -3530 {lab=#net64}
N 4150 -3470 4410 -3470 {lab=GND}
N 4450 -3500 4450 -3440 {lab=#net59}
N 4080 -3440 4450 -3440 {lab=#net59}
N 4080 -3500 4080 -3440 {lab=#net59}
N 4450 -3790 4450 -3680 {lab=#net59}
N 4080 -3790 4450 -3790 {lab=#net59}
N 4080 -3790 4080 -3680 {lab=#net59}
N 4110 -5120 4150 -5120 {lab=#net60}
N 4150 -5240 4410 -5240 {lab=VDD}
N 4150 -5120 4410 -5120 {lab=#net60}
N 4410 -5180 4410 -5120 {lab=#net60}
N 4410 -5120 4410 -5060 {lab=#net60}
N 4150 -5000 4410 -5000 {lab=GND}
N 4450 -5030 4450 -4970 {lab=#net55}
N 4080 -4970 4450 -4970 {lab=#net55}
N 4080 -5030 4080 -4970 {lab=#net55}
N 4450 -5320 4450 -5210 {lab=#net55}
N 4080 -5320 4450 -5320 {lab=#net55}
N 4080 -5320 4080 -5210 {lab=#net55}
N 4110 -4740 4150 -4740 {lab=#net61}
N 4150 -4860 4410 -4860 {lab=VDD}
N 4150 -4740 4410 -4740 {lab=#net61}
N 4410 -4800 4410 -4740 {lab=#net61}
N 4410 -4740 4410 -4680 {lab=#net61}
N 4150 -4620 4410 -4620 {lab=GND}
N 4450 -4650 4450 -4590 {lab=#net56}
N 4080 -4590 4450 -4590 {lab=#net56}
N 4080 -4650 4080 -4590 {lab=#net56}
N 4450 -4940 4450 -4830 {lab=#net56}
N 4080 -4940 4450 -4940 {lab=#net56}
N 4080 -4940 4080 -4830 {lab=#net56}
N 4110 -4360 4150 -4360 {lab=#net62}
N 4150 -4480 4410 -4480 {lab=VDD}
N 4150 -4360 4410 -4360 {lab=#net62}
N 4410 -4420 4410 -4360 {lab=#net62}
N 4410 -4360 4410 -4300 {lab=#net62}
N 4150 -4240 4410 -4240 {lab=GND}
N 4450 -4270 4450 -4210 {lab=#net57}
N 4080 -4210 4450 -4210 {lab=#net57}
N 4080 -4270 4080 -4210 {lab=#net57}
N 4450 -4560 4450 -4450 {lab=#net57}
N 4080 -4560 4450 -4560 {lab=#net57}
N 4080 -4560 4080 -4450 {lab=#net57}
N 4110 -3980 4150 -3980 {lab=#net63}
N 4150 -4100 4410 -4100 {lab=VDD}
N 4410 -4040 4410 -3980 {lab=#net63}
N 4410 -3980 4410 -3920 {lab=#net63}
N 4150 -3860 4410 -3860 {lab=GND}
N 4450 -3890 4450 -3830 {lab=#net58}
N 4080 -3830 4450 -3830 {lab=#net58}
N 4080 -3890 4080 -3830 {lab=#net58}
N 4450 -4180 4450 -4070 {lab=#net58}
N 4080 -4180 4450 -4180 {lab=#net58}
N 4080 -4180 4080 -4070 {lab=#net58}
N 4150 -5300 4150 -5240 {lab=VDD}
N 4150 -4920 4150 -4860 {lab=VDD}
N 4150 -4540 4150 -4480 {lab=VDD}
N 4150 -4160 4150 -4100 {lab=VDD}
N 4150 -3770 4150 -3710 {lab=VDD}
N 4410 -3590 4480 -3590 {lab=#net64}
N 2920 -3980 3180 -3980 {lab=#net48}
N 3330 -3980 3590 -3980 {lab=#net53}
N 3740 -3980 4000 -3980 {lab=#net58}
N 4150 -3980 4410 -3980 {lab=#net63}
N 4550 -5000 4550 -4990 {lab=GND}
N 4510 -5120 4550 -5120 {lab=#net65}
N 4510 -5150 4510 -5120 {lab=#net65}
N 4510 -5120 4510 -5090 {lab=#net65}
N 4550 -4620 4550 -4610 {lab=GND}
N 4510 -4740 4550 -4740 {lab=#net66}
N 4510 -4770 4510 -4740 {lab=#net66}
N 4510 -4740 4510 -4710 {lab=#net66}
N 4550 -4240 4550 -4230 {lab=GND}
N 4510 -4360 4550 -4360 {lab=#net67}
N 4510 -4390 4510 -4360 {lab=#net67}
N 4510 -4360 4510 -4330 {lab=#net67}
N 4550 -3860 4550 -3850 {lab=GND}
N 4510 -3980 4550 -3980 {lab=#net68}
N 4510 -4010 4510 -3980 {lab=#net68}
N 4510 -3980 4510 -3950 {lab=#net68}
N 4550 -3470 4550 -3460 {lab=GND}
N 4510 -3590 4550 -3590 {lab=#net69}
N 4510 -3620 4510 -3590 {lab=#net69}
N 4510 -3590 4510 -3560 {lab=#net69}
N 4480 -3500 4510 -3500 {lab=#net64}
N 4480 -3680 4480 -3500 {lab=#net64}
N 4480 -3680 4510 -3680 {lab=#net64}
N 4480 -3890 4510 -3890 {lab=#net63}
N 4480 -4070 4480 -3890 {lab=#net63}
N 4480 -4070 4510 -4070 {lab=#net63}
N 4480 -4450 4510 -4450 {lab=#net62}
N 4480 -4450 4480 -4270 {lab=#net62}
N 4480 -4270 4510 -4270 {lab=#net62}
N 4480 -4650 4510 -4650 {lab=#net61}
N 4480 -4830 4480 -4650 {lab=#net61}
N 4480 -4830 4510 -4830 {lab=#net61}
N 4480 -5210 4510 -5210 {lab=#net60}
N 4480 -5210 4480 -5030 {lab=#net60}
N 4480 -5030 4510 -5030 {lab=#net60}
N 4510 -3590 4550 -3590 {lab=#net69}
N 4550 -3710 4810 -3710 {lab=VDD}
N 4550 -3590 4810 -3590 {lab=#net69}
N 4810 -3650 4810 -3590 {lab=#net69}
N 4810 -3590 4810 -3530 {lab=#net69}
N 4550 -3470 4810 -3470 {lab=GND}
N 4850 -3500 4850 -3440 {lab=#net64}
N 4480 -3440 4850 -3440 {lab=#net64}
N 4480 -3500 4480 -3440 {lab=#net64}
N 4850 -3790 4850 -3680 {lab=#net64}
N 4480 -3790 4850 -3790 {lab=#net64}
N 4480 -3790 4480 -3680 {lab=#net64}
N 4510 -5120 4550 -5120 {lab=#net65}
N 4550 -5240 4810 -5240 {lab=VDD}
N 4550 -5120 4810 -5120 {lab=#net65}
N 4810 -5180 4810 -5120 {lab=#net65}
N 4810 -5120 4810 -5060 {lab=#net65}
N 4550 -5000 4810 -5000 {lab=GND}
N 4850 -5030 4850 -4970 {lab=#net60}
N 4480 -4970 4850 -4970 {lab=#net60}
N 4480 -5030 4480 -4970 {lab=#net60}
N 4850 -5320 4850 -5210 {lab=#net60}
N 4480 -5320 4850 -5320 {lab=#net60}
N 4480 -5320 4480 -5210 {lab=#net60}
N 4510 -4740 4550 -4740 {lab=#net66}
N 4550 -4860 4810 -4860 {lab=VDD}
N 4550 -4740 4810 -4740 {lab=#net66}
N 4810 -4800 4810 -4740 {lab=#net66}
N 4810 -4740 4810 -4680 {lab=#net66}
N 4550 -4620 4810 -4620 {lab=GND}
N 4850 -4650 4850 -4590 {lab=#net61}
N 4480 -4590 4850 -4590 {lab=#net61}
N 4480 -4650 4480 -4590 {lab=#net61}
N 4850 -4940 4850 -4830 {lab=#net61}
N 4480 -4940 4850 -4940 {lab=#net61}
N 4480 -4940 4480 -4830 {lab=#net61}
N 4510 -4360 4550 -4360 {lab=#net67}
N 4550 -4480 4810 -4480 {lab=VDD}
N 4550 -4360 4810 -4360 {lab=#net67}
N 4810 -4420 4810 -4360 {lab=#net67}
N 4810 -4360 4810 -4300 {lab=#net67}
N 4550 -4240 4810 -4240 {lab=GND}
N 4850 -4270 4850 -4210 {lab=#net62}
N 4480 -4210 4850 -4210 {lab=#net62}
N 4480 -4270 4480 -4210 {lab=#net62}
N 4850 -4560 4850 -4450 {lab=#net62}
N 4480 -4560 4850 -4560 {lab=#net62}
N 4480 -4560 4480 -4450 {lab=#net62}
N 4510 -3980 4550 -3980 {lab=#net68}
N 4550 -4100 4810 -4100 {lab=VDD}
N 4550 -3980 4810 -3980 {lab=#net68}
N 4810 -4040 4810 -3980 {lab=#net68}
N 4810 -3980 4810 -3920 {lab=#net68}
N 4550 -3860 4810 -3860 {lab=GND}
N 4850 -3890 4850 -3830 {lab=#net63}
N 4480 -3830 4850 -3830 {lab=#net63}
N 4480 -3890 4480 -3830 {lab=#net63}
N 4850 -4180 4850 -4070 {lab=#net63}
N 4480 -4180 4850 -4180 {lab=#net63}
N 4480 -4180 4480 -4070 {lab=#net63}
N 4810 -5120 4890 -5120 {lab=#net65}
N 4550 -5300 4550 -5240 {lab=VDD}
N 4550 -4920 4550 -4860 {lab=VDD}
N 4810 -4740 4890 -4740 {lab=#net66}
N 4550 -4540 4550 -4480 {lab=VDD}
N 4550 -4160 4550 -4100 {lab=VDD}
N 4810 -4360 4890 -4360 {lab=#net67}
N 4810 -3980 4890 -3980 {lab=#net68}
N 4550 -3770 4550 -3710 {lab=VDD}
N 4810 -3590 4880 -3590 {lab=#net69}
N 4880 -3590 4890 -3590 {lab=#net69}
N 4960 -5000 4960 -4990 {lab=GND}
N 4920 -5120 4960 -5120 {lab=#net70}
N 4920 -5150 4920 -5120 {lab=#net70}
N 4920 -5120 4920 -5090 {lab=#net70}
N 4960 -4620 4960 -4610 {lab=GND}
N 4920 -4740 4960 -4740 {lab=#net71}
N 4920 -4770 4920 -4740 {lab=#net71}
N 4920 -4740 4920 -4710 {lab=#net71}
N 4960 -4240 4960 -4230 {lab=GND}
N 4920 -4360 4960 -4360 {lab=#net72}
N 4920 -4390 4920 -4360 {lab=#net72}
N 4920 -4360 4920 -4330 {lab=#net72}
N 4960 -3860 4960 -3850 {lab=GND}
N 4920 -3980 4960 -3980 {lab=#net73}
N 4920 -4010 4920 -3980 {lab=#net73}
N 4920 -3980 4920 -3950 {lab=#net73}
N 4960 -3470 4960 -3460 {lab=GND}
N 4920 -3590 4960 -3590 {lab=#net74}
N 4920 -3620 4920 -3590 {lab=#net74}
N 4920 -3590 4920 -3560 {lab=#net74}
N 4890 -3500 4920 -3500 {lab=#net69}
N 4890 -3680 4890 -3500 {lab=#net69}
N 4890 -3680 4920 -3680 {lab=#net69}
N 4890 -3890 4920 -3890 {lab=#net68}
N 4890 -4070 4890 -3890 {lab=#net68}
N 4890 -4070 4920 -4070 {lab=#net68}
N 4890 -4450 4920 -4450 {lab=#net67}
N 4890 -4450 4890 -4270 {lab=#net67}
N 4890 -4270 4920 -4270 {lab=#net67}
N 4890 -4650 4920 -4650 {lab=#net66}
N 4890 -4830 4890 -4650 {lab=#net66}
N 4890 -4830 4920 -4830 {lab=#net66}
N 4890 -5210 4920 -5210 {lab=#net65}
N 4890 -5210 4890 -5030 {lab=#net65}
N 4890 -5030 4920 -5030 {lab=#net65}
N 4920 -3590 4960 -3590 {lab=#net74}
N 4960 -3710 5220 -3710 {lab=VDD}
N 4960 -3590 5220 -3590 {lab=#net74}
N 5220 -3650 5220 -3590 {lab=#net74}
N 5220 -3590 5220 -3530 {lab=#net74}
N 4960 -3470 5220 -3470 {lab=GND}
N 5260 -3500 5260 -3440 {lab=#net69}
N 4890 -3440 5260 -3440 {lab=#net69}
N 4890 -3500 4890 -3440 {lab=#net69}
N 5260 -3790 5260 -3680 {lab=#net69}
N 4890 -3790 5260 -3790 {lab=#net69}
N 4890 -3790 4890 -3680 {lab=#net69}
N 4920 -5120 4960 -5120 {lab=#net70}
N 4960 -5240 5220 -5240 {lab=VDD}
N 4960 -5120 5220 -5120 {lab=#net70}
N 5220 -5180 5220 -5120 {lab=#net70}
N 5220 -5120 5220 -5060 {lab=#net70}
N 4960 -5000 5220 -5000 {lab=GND}
N 5260 -5030 5260 -4970 {lab=#net65}
N 4890 -4970 5260 -4970 {lab=#net65}
N 4890 -5030 4890 -4970 {lab=#net65}
N 5260 -5320 5260 -5210 {lab=#net65}
N 4890 -5320 5260 -5320 {lab=#net65}
N 4890 -5320 4890 -5210 {lab=#net65}
N 4920 -4740 4960 -4740 {lab=#net71}
N 4960 -4860 5220 -4860 {lab=VDD}
N 4960 -4740 5220 -4740 {lab=#net71}
N 5220 -4800 5220 -4740 {lab=#net71}
N 5220 -4740 5220 -4680 {lab=#net71}
N 4960 -4620 5220 -4620 {lab=GND}
N 5260 -4650 5260 -4590 {lab=#net66}
N 4890 -4590 5260 -4590 {lab=#net66}
N 4890 -4650 4890 -4590 {lab=#net66}
N 5260 -4940 5260 -4830 {lab=#net66}
N 4890 -4940 5260 -4940 {lab=#net66}
N 4890 -4940 4890 -4830 {lab=#net66}
N 4920 -4360 4960 -4360 {lab=#net72}
N 4960 -4480 5220 -4480 {lab=VDD}
N 4960 -4360 5220 -4360 {lab=#net72}
N 5220 -4420 5220 -4360 {lab=#net72}
N 5220 -4360 5220 -4300 {lab=#net72}
N 4960 -4240 5220 -4240 {lab=GND}
N 5260 -4270 5260 -4210 {lab=#net67}
N 4890 -4210 5260 -4210 {lab=#net67}
N 4890 -4270 4890 -4210 {lab=#net67}
N 5260 -4560 5260 -4450 {lab=#net67}
N 4890 -4560 5260 -4560 {lab=#net67}
N 4890 -4560 4890 -4450 {lab=#net67}
N 4920 -3980 4960 -3980 {lab=#net73}
N 4960 -4100 5220 -4100 {lab=VDD}
N 5220 -4040 5220 -3980 {lab=#net73}
N 5220 -3980 5220 -3920 {lab=#net73}
N 4960 -3860 5220 -3860 {lab=GND}
N 5260 -3890 5260 -3830 {lab=#net68}
N 4890 -3830 5260 -3830 {lab=#net68}
N 4890 -3890 4890 -3830 {lab=#net68}
N 5260 -4180 5260 -4070 {lab=#net68}
N 4890 -4180 5260 -4180 {lab=#net68}
N 4890 -4180 4890 -4070 {lab=#net68}
N 5220 -5120 5300 -5120 {lab=#net70}
N 4960 -5300 4960 -5240 {lab=VDD}
N 4960 -4920 4960 -4860 {lab=VDD}
N 5220 -4740 5300 -4740 {lab=#net71}
N 4960 -4540 4960 -4480 {lab=VDD}
N 4960 -4160 4960 -4100 {lab=VDD}
N 5220 -4360 5300 -4360 {lab=#net72}
N 5220 -3980 5300 -3980 {lab=#net73}
N 4960 -3770 4960 -3710 {lab=VDD}
N 5220 -3590 5290 -3590 {lab=#net74}
N 5290 -3590 5300 -3590 {lab=#net74}
N 5370 -5000 5370 -4990 {lab=GND}
N 5330 -5120 5370 -5120 {lab=#net75}
N 5330 -5150 5330 -5120 {lab=#net75}
N 5330 -5120 5330 -5090 {lab=#net75}
N 5370 -4620 5370 -4610 {lab=GND}
N 5330 -4740 5370 -4740 {lab=#net76}
N 5330 -4770 5330 -4740 {lab=#net76}
N 5330 -4740 5330 -4710 {lab=#net76}
N 5370 -4240 5370 -4230 {lab=GND}
N 5330 -4360 5370 -4360 {lab=#net77}
N 5330 -4390 5330 -4360 {lab=#net77}
N 5330 -4360 5330 -4330 {lab=#net77}
N 5370 -3860 5370 -3850 {lab=GND}
N 5330 -3980 5370 -3980 {lab=#net78}
N 5330 -4010 5330 -3980 {lab=#net78}
N 5330 -3980 5330 -3950 {lab=#net78}
N 5370 -3470 5370 -3460 {lab=GND}
N 5330 -3590 5370 -3590 {lab=#net79}
N 5330 -3620 5330 -3590 {lab=#net79}
N 5330 -3590 5330 -3560 {lab=#net79}
N 5300 -3500 5330 -3500 {lab=#net74}
N 5300 -3680 5300 -3500 {lab=#net74}
N 5300 -3680 5330 -3680 {lab=#net74}
N 5300 -3890 5330 -3890 {lab=#net73}
N 5300 -4070 5300 -3890 {lab=#net73}
N 5300 -4070 5330 -4070 {lab=#net73}
N 5300 -4450 5330 -4450 {lab=#net72}
N 5300 -4450 5300 -4270 {lab=#net72}
N 5300 -4270 5330 -4270 {lab=#net72}
N 5300 -4650 5330 -4650 {lab=#net71}
N 5300 -4830 5300 -4650 {lab=#net71}
N 5300 -4830 5330 -4830 {lab=#net71}
N 5300 -5210 5330 -5210 {lab=#net70}
N 5300 -5210 5300 -5030 {lab=#net70}
N 5300 -5030 5330 -5030 {lab=#net70}
N 5330 -3590 5370 -3590 {lab=#net79}
N 5370 -3710 5630 -3710 {lab=VDD}
N 5370 -3590 5630 -3590 {lab=#net79}
N 5630 -3650 5630 -3590 {lab=#net79}
N 5630 -3590 5630 -3530 {lab=#net79}
N 5370 -3470 5630 -3470 {lab=GND}
N 5670 -3500 5670 -3440 {lab=#net74}
N 5300 -3440 5670 -3440 {lab=#net74}
N 5300 -3500 5300 -3440 {lab=#net74}
N 5670 -3790 5670 -3680 {lab=#net74}
N 5300 -3790 5670 -3790 {lab=#net74}
N 5300 -3790 5300 -3680 {lab=#net74}
N 5330 -5120 5370 -5120 {lab=#net75}
N 5370 -5240 5630 -5240 {lab=VDD}
N 5370 -5120 5630 -5120 {lab=#net75}
N 5630 -5180 5630 -5120 {lab=#net75}
N 5630 -5120 5630 -5060 {lab=#net75}
N 5370 -5000 5630 -5000 {lab=GND}
N 5670 -5030 5670 -4970 {lab=#net70}
N 5300 -4970 5670 -4970 {lab=#net70}
N 5300 -5030 5300 -4970 {lab=#net70}
N 5670 -5320 5670 -5210 {lab=#net70}
N 5300 -5320 5670 -5320 {lab=#net70}
N 5300 -5320 5300 -5210 {lab=#net70}
N 5330 -4740 5370 -4740 {lab=#net76}
N 5370 -4860 5630 -4860 {lab=VDD}
N 5370 -4740 5630 -4740 {lab=#net76}
N 5630 -4800 5630 -4740 {lab=#net76}
N 5630 -4740 5630 -4680 {lab=#net76}
N 5370 -4620 5630 -4620 {lab=GND}
N 5670 -4650 5670 -4590 {lab=#net71}
N 5300 -4590 5670 -4590 {lab=#net71}
N 5300 -4650 5300 -4590 {lab=#net71}
N 5670 -4940 5670 -4830 {lab=#net71}
N 5300 -4940 5670 -4940 {lab=#net71}
N 5300 -4940 5300 -4830 {lab=#net71}
N 5330 -4360 5370 -4360 {lab=#net77}
N 5370 -4480 5630 -4480 {lab=VDD}
N 5370 -4360 5630 -4360 {lab=#net77}
N 5630 -4420 5630 -4360 {lab=#net77}
N 5630 -4360 5630 -4300 {lab=#net77}
N 5370 -4240 5630 -4240 {lab=GND}
N 5670 -4270 5670 -4210 {lab=#net72}
N 5300 -4210 5670 -4210 {lab=#net72}
N 5300 -4270 5300 -4210 {lab=#net72}
N 5670 -4560 5670 -4450 {lab=#net72}
N 5300 -4560 5670 -4560 {lab=#net72}
N 5300 -4560 5300 -4450 {lab=#net72}
N 5330 -3980 5370 -3980 {lab=#net78}
N 5370 -4100 5630 -4100 {lab=VDD}
N 5630 -4040 5630 -3980 {lab=#net78}
N 5630 -3980 5630 -3920 {lab=#net78}
N 5370 -3860 5630 -3860 {lab=GND}
N 5670 -3890 5670 -3830 {lab=#net73}
N 5300 -3830 5670 -3830 {lab=#net73}
N 5300 -3890 5300 -3830 {lab=#net73}
N 5670 -4180 5670 -4070 {lab=#net73}
N 5300 -4180 5670 -4180 {lab=#net73}
N 5300 -4180 5300 -4070 {lab=#net73}
N 5630 -5120 5710 -5120 {lab=#net75}
N 5370 -5300 5370 -5240 {lab=VDD}
N 5370 -4920 5370 -4860 {lab=VDD}
N 5630 -4740 5710 -4740 {lab=#net76}
N 5370 -4540 5370 -4480 {lab=VDD}
N 5370 -4160 5370 -4100 {lab=VDD}
N 5630 -4360 5710 -4360 {lab=#net77}
N 5630 -3980 5710 -3980 {lab=#net78}
N 5370 -3770 5370 -3710 {lab=VDD}
N 5630 -3590 5700 -3590 {lab=#net79}
N 5700 -3590 5710 -3590 {lab=#net79}
N 5780 -5000 5780 -4990 {lab=GND}
N 5740 -5120 5780 -5120 {lab=#net80}
N 5740 -5150 5740 -5120 {lab=#net80}
N 5740 -5120 5740 -5090 {lab=#net80}
N 5780 -4620 5780 -4610 {lab=GND}
N 5740 -4740 5780 -4740 {lab=#net81}
N 5740 -4770 5740 -4740 {lab=#net81}
N 5740 -4740 5740 -4710 {lab=#net81}
N 5780 -4240 5780 -4230 {lab=GND}
N 5740 -4360 5780 -4360 {lab=#net82}
N 5740 -4390 5740 -4360 {lab=#net82}
N 5740 -4360 5740 -4330 {lab=#net82}
N 5780 -3860 5780 -3850 {lab=GND}
N 5740 -3980 5780 -3980 {lab=#net83}
N 5740 -4010 5740 -3980 {lab=#net83}
N 5740 -3980 5740 -3950 {lab=#net83}
N 5780 -3470 5780 -3460 {lab=GND}
N 5740 -3590 5780 -3590 {lab=#net84}
N 5740 -3620 5740 -3590 {lab=#net84}
N 5740 -3590 5740 -3560 {lab=#net84}
N 5710 -3500 5740 -3500 {lab=#net79}
N 5710 -3680 5710 -3500 {lab=#net79}
N 5710 -3680 5740 -3680 {lab=#net79}
N 5710 -3890 5740 -3890 {lab=#net78}
N 5710 -4070 5710 -3890 {lab=#net78}
N 5710 -4070 5740 -4070 {lab=#net78}
N 5710 -4450 5740 -4450 {lab=#net77}
N 5710 -4450 5710 -4270 {lab=#net77}
N 5710 -4270 5740 -4270 {lab=#net77}
N 5710 -4650 5740 -4650 {lab=#net76}
N 5710 -4830 5710 -4650 {lab=#net76}
N 5710 -4830 5740 -4830 {lab=#net76}
N 5710 -5210 5740 -5210 {lab=#net75}
N 5710 -5210 5710 -5030 {lab=#net75}
N 5710 -5030 5740 -5030 {lab=#net75}
N 5740 -3590 5780 -3590 {lab=#net84}
N 5780 -3710 6040 -3710 {lab=VDD}
N 5780 -3590 6040 -3590 {lab=#net84}
N 6040 -3650 6040 -3590 {lab=#net84}
N 6040 -3590 6040 -3530 {lab=#net84}
N 5780 -3470 6040 -3470 {lab=GND}
N 6080 -3500 6080 -3440 {lab=#net79}
N 5710 -3440 6080 -3440 {lab=#net79}
N 5710 -3500 5710 -3440 {lab=#net79}
N 6080 -3790 6080 -3680 {lab=#net79}
N 5710 -3790 6080 -3790 {lab=#net79}
N 5710 -3790 5710 -3680 {lab=#net79}
N 5740 -5120 5780 -5120 {lab=#net80}
N 5780 -5240 6040 -5240 {lab=VDD}
N 5780 -5120 6040 -5120 {lab=#net80}
N 6040 -5180 6040 -5120 {lab=#net80}
N 6040 -5120 6040 -5060 {lab=#net80}
N 5780 -5000 6040 -5000 {lab=GND}
N 6080 -5030 6080 -4970 {lab=#net75}
N 5710 -4970 6080 -4970 {lab=#net75}
N 5710 -5030 5710 -4970 {lab=#net75}
N 6080 -5320 6080 -5210 {lab=#net75}
N 5710 -5320 6080 -5320 {lab=#net75}
N 5710 -5320 5710 -5210 {lab=#net75}
N 5740 -4740 5780 -4740 {lab=#net81}
N 5780 -4860 6040 -4860 {lab=VDD}
N 5780 -4740 6040 -4740 {lab=#net81}
N 6040 -4800 6040 -4740 {lab=#net81}
N 6040 -4740 6040 -4680 {lab=#net81}
N 5780 -4620 6040 -4620 {lab=GND}
N 6080 -4650 6080 -4590 {lab=#net76}
N 5710 -4590 6080 -4590 {lab=#net76}
N 5710 -4650 5710 -4590 {lab=#net76}
N 6080 -4940 6080 -4830 {lab=#net76}
N 5710 -4940 6080 -4940 {lab=#net76}
N 5710 -4940 5710 -4830 {lab=#net76}
N 5740 -4360 5780 -4360 {lab=#net82}
N 5780 -4480 6040 -4480 {lab=VDD}
N 5780 -4360 6040 -4360 {lab=#net82}
N 6040 -4420 6040 -4360 {lab=#net82}
N 6040 -4360 6040 -4300 {lab=#net82}
N 5780 -4240 6040 -4240 {lab=GND}
N 6080 -4270 6080 -4210 {lab=#net77}
N 5710 -4210 6080 -4210 {lab=#net77}
N 5710 -4270 5710 -4210 {lab=#net77}
N 6080 -4560 6080 -4450 {lab=#net77}
N 5710 -4560 6080 -4560 {lab=#net77}
N 5710 -4560 5710 -4450 {lab=#net77}
N 5740 -3980 5780 -3980 {lab=#net83}
N 5780 -4100 6040 -4100 {lab=VDD}
N 6040 -4040 6040 -3980 {lab=#net83}
N 6040 -3980 6040 -3920 {lab=#net83}
N 5780 -3860 6040 -3860 {lab=GND}
N 6080 -3890 6080 -3830 {lab=#net78}
N 5710 -3830 6080 -3830 {lab=#net78}
N 5710 -3890 5710 -3830 {lab=#net78}
N 6080 -4180 6080 -4070 {lab=#net78}
N 5710 -4180 6080 -4180 {lab=#net78}
N 5710 -4180 5710 -4070 {lab=#net78}
N 6040 -5120 6120 -5120 {lab=#net80}
N 5780 -5300 5780 -5240 {lab=VDD}
N 5780 -4920 5780 -4860 {lab=VDD}
N 6040 -4740 6120 -4740 {lab=#net81}
N 5780 -4540 5780 -4480 {lab=VDD}
N 5780 -4160 5780 -4100 {lab=VDD}
N 6040 -4360 6120 -4360 {lab=#net82}
N 6040 -3980 6120 -3980 {lab=#net83}
N 5780 -3770 5780 -3710 {lab=VDD}
N 6040 -3590 6110 -3590 {lab=#net84}
N 6110 -3590 6120 -3590 {lab=#net84}
N 6190 -5000 6190 -4990 {lab=GND}
N 6150 -5120 6190 -5120 {lab=o5d}
N 6150 -5150 6150 -5120 {lab=o5d}
N 6150 -5120 6150 -5090 {lab=o5d}
N 6190 -4620 6190 -4610 {lab=GND}
N 6150 -4740 6190 -4740 {lab=o6d}
N 6150 -4770 6150 -4740 {lab=o6d}
N 6150 -4740 6150 -4710 {lab=o6d}
N 6190 -4240 6190 -4230 {lab=GND}
N 6150 -4360 6190 -4360 {lab=o7d}
N 6150 -4390 6150 -4360 {lab=o7d}
N 6150 -4360 6150 -4330 {lab=o7d}
N 6190 -3860 6190 -3850 {lab=GND}
N 6150 -3980 6190 -3980 {lab=o8d}
N 6150 -4010 6150 -3980 {lab=o8d}
N 6150 -3980 6150 -3950 {lab=o8d}
N 6190 -3470 6190 -3460 {lab=GND}
N 6150 -3590 6190 -3590 {lab=o9d}
N 6150 -3620 6150 -3590 {lab=o9d}
N 6150 -3590 6150 -3560 {lab=o9d}
N 6120 -3500 6150 -3500 {lab=#net84}
N 6120 -3680 6120 -3500 {lab=#net84}
N 6120 -3680 6150 -3680 {lab=#net84}
N 6120 -3890 6150 -3890 {lab=#net83}
N 6120 -4070 6120 -3890 {lab=#net83}
N 6120 -4070 6150 -4070 {lab=#net83}
N 6120 -4450 6150 -4450 {lab=#net82}
N 6120 -4450 6120 -4270 {lab=#net82}
N 6120 -4270 6150 -4270 {lab=#net82}
N 6120 -4650 6150 -4650 {lab=#net81}
N 6120 -4830 6120 -4650 {lab=#net81}
N 6120 -4830 6150 -4830 {lab=#net81}
N 6120 -5210 6150 -5210 {lab=#net80}
N 6120 -5210 6120 -5030 {lab=#net80}
N 6120 -5030 6150 -5030 {lab=#net80}
N 6150 -3590 6190 -3590 {lab=o9d}
N 6190 -3710 6450 -3710 {lab=VDD}
N 6190 -3590 6450 -3590 {lab=o9d}
N 6450 -3650 6450 -3590 {lab=o9d}
N 6450 -3590 6450 -3530 {lab=o9d}
N 6190 -3470 6450 -3470 {lab=GND}
N 6490 -3500 6490 -3440 {lab=#net84}
N 6120 -3440 6490 -3440 {lab=#net84}
N 6120 -3500 6120 -3440 {lab=#net84}
N 6490 -3790 6490 -3680 {lab=#net84}
N 6120 -3790 6490 -3790 {lab=#net84}
N 6120 -3790 6120 -3680 {lab=#net84}
N 6150 -5120 6190 -5120 {lab=o5d}
N 6190 -5240 6450 -5240 {lab=VDD}
N 6190 -5120 6450 -5120 {lab=o5d}
N 6450 -5180 6450 -5120 {lab=o5d}
N 6450 -5120 6450 -5060 {lab=o5d}
N 6190 -5000 6450 -5000 {lab=GND}
N 6490 -5030 6490 -4970 {lab=#net80}
N 6120 -4970 6490 -4970 {lab=#net80}
N 6120 -5030 6120 -4970 {lab=#net80}
N 6490 -5320 6490 -5210 {lab=#net80}
N 6120 -5320 6490 -5320 {lab=#net80}
N 6120 -5320 6120 -5210 {lab=#net80}
N 6150 -4740 6190 -4740 {lab=o6d}
N 6190 -4860 6450 -4860 {lab=VDD}
N 6190 -4740 6450 -4740 {lab=o6d}
N 6450 -4800 6450 -4740 {lab=o6d}
N 6450 -4740 6450 -4680 {lab=o6d}
N 6190 -4620 6450 -4620 {lab=GND}
N 6490 -4650 6490 -4590 {lab=#net81}
N 6120 -4590 6490 -4590 {lab=#net81}
N 6120 -4650 6120 -4590 {lab=#net81}
N 6490 -4940 6490 -4830 {lab=#net81}
N 6120 -4940 6490 -4940 {lab=#net81}
N 6120 -4940 6120 -4830 {lab=#net81}
N 6150 -4360 6190 -4360 {lab=o7d}
N 6190 -4480 6450 -4480 {lab=VDD}
N 6190 -4360 6450 -4360 {lab=o7d}
N 6450 -4420 6450 -4360 {lab=o7d}
N 6450 -4360 6450 -4300 {lab=o7d}
N 6190 -4240 6450 -4240 {lab=GND}
N 6490 -4270 6490 -4210 {lab=#net82}
N 6120 -4210 6490 -4210 {lab=#net82}
N 6120 -4270 6120 -4210 {lab=#net82}
N 6490 -4560 6490 -4450 {lab=#net82}
N 6120 -4560 6490 -4560 {lab=#net82}
N 6120 -4560 6120 -4450 {lab=#net82}
N 6150 -3980 6190 -3980 {lab=o8d}
N 6190 -4100 6450 -4100 {lab=VDD}
N 6450 -4040 6450 -3980 {lab=o8d}
N 6450 -3980 6450 -3920 {lab=o8d}
N 6190 -3860 6450 -3860 {lab=GND}
N 6490 -3890 6490 -3830 {lab=#net83}
N 6120 -3830 6490 -3830 {lab=#net83}
N 6120 -3890 6120 -3830 {lab=#net83}
N 6490 -4180 6490 -4070 {lab=#net83}
N 6120 -4180 6490 -4180 {lab=#net83}
N 6120 -4180 6120 -4070 {lab=#net83}
N 6190 -5300 6190 -5240 {lab=VDD}
N 6190 -4920 6190 -4860 {lab=VDD}
N 6190 -4540 6190 -4480 {lab=VDD}
N 6190 -4160 6190 -4100 {lab=VDD}
N 6190 -3770 6190 -3710 {lab=VDD}
N 4960 -3980 5220 -3980 {lab=#net73}
N 5370 -3980 5630 -3980 {lab=#net78}
N 5780 -3980 6040 -3980 {lab=#net83}
N 6190 -3980 6450 -3980 {lab=o8d}
N 4410 -3980 4480 -3980 {lab=#net63}
N 4410 -4360 4480 -4360 {lab=#net62}
N 4410 -4740 4480 -4740 {lab=#net61}
N 4410 -5120 4480 -5120 {lab=#net60}
C {title.sym} 170 -40 0 0 {name=l1 author="Timonas Juonys"}
C {lab_pin.sym} 260 -1080 3 1 {name=p2 sig_type=std_logic lab=o10}
C {lab_pin.sym} 150 -1080 0 0 {name=p6 sig_type=std_logic lab=in}
C {code_shown.sym} 16.74901121701339 -861.7671459816082 0 0 {name=s1 only_toplevel=false value="
.global VDD GND BP BN
.option temp=27
.include /usr/local/share/pdk/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /usr/local/share/pdk/gf180mcuC/libs.tech/ngspice/sm141064.ngspice typical

Vdd VDD 0 3.3
Vdd2 VDD2 0 1.67
Vbp BP VDD 2.7
Vbn BN GND -2.7
Vin in 0 PWL(0 0 100n 3.3)
Vind ind 0 PWL(0 0 49.9n 0 50.1n 1.425 99.9n 1.425 100.1n 3.3 149.9n 3.3 150.1n 1.425 199.9n 1.425 200.1n 0 250n 0)

.control
  save all
  tran 0.05n 250n
  meas tran t_cross WHEN v(o5d)=1.25 CROSS=1
  meas tran t_cross WHEN v(o6d)=1.25 CROSS=1
  meas tran t_cross WHEN v(o7d)=1.25 CROSS=1
  meas tran t_cross WHEN v(o8d)=1.25 CROSS=1
  meas tran t_cross WHEN v(o9d)=1.25 CROSS=1
  write STI_TB.raw
.endc
.end
"}
C {xschem_designs/STI.sym} 190 -1080 0 0 {name=x1}
C {gnd.sym} 170 -990 0 0 {name=l2 lab=0}
C {lab_pin.sym} 170 -1010 0 0 {name=p7 sig_type=std_logic lab=GND}
C {launcher.sym} 2010 -140 0 0 {name=h5
descr="load waves"
tclcommand="xschem raw_read $netlist_dir/STI_TB.raw tran"
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 1770 -1000 0 1 {name=M5
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 1770 -1180 0 1 {name=M6
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {lab_pin.sym} 1620 -1290 0 0 {name=p16 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1620 -950 0 0 {name=p17 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1440 -1180 0 0 {name=p18 sig_type=std_logic lab=in}
C {lab_pin.sym} 1440 -1000 0 0 {name=p19 sig_type=std_logic lab=in}
C {lab_pin.sym} 1790 -1000 0 1 {name=p20 sig_type=std_logic lab=in}
C {lab_pin.sym} 1790 -1180 0 1 {name=p21 sig_type=std_logic lab=in}
C {lab_pin.sym} 1750 -1090 0 1 {name=p13 sig_type=std_logic lab=out}
C {ammeter.sym} 1620 -1260 0 0 {name=Vmeas savecurrent=true spice_ignore=0}
C {gf180mcu_fd_pr/nfet_03v3_dss.sym} 1460 -1000 0 0 {name=M2
L=0.28u
W=0.44u
nf=1
m=1
d_sab=3.78u
s_sab=0.28u
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dss
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet_03v3_dss.sym} 1460 -1180 0 0 {name=M8
L=0.28u
W=0.88u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
s_sab=0.28u 
d_sab=2.78u 
sa=0 sb=0 sd=0
model=pfet_03v3_dss
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet_03v3_dss.sym} 1460 -1120 0 0 {name=M1
L=2.8u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
s_sab=0.28u 
d_sab=2.78u 
sa=0 sb=0 sd=0
model=pfet_03v3_dss
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet_03v3_dss.sym} 1460 -1060 0 0 {name=M3
L=2.8u
W=0.22u
nf=1
m=1
d_sab=3.78u
s_sab=0.28u
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dss
spiceprefix=X
}
C {lab_pin.sym} 600 -380 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 600 -160 0 0 {name=p15 sig_type=std_logic lab=GND}
C {lab_pin.sym} 840 -240 0 0 {name=p25 sig_type=std_logic lab=in}
C {lab_pin.sym} 600 -240 0 1 {name=p26 sig_type=std_logic lab=o1}
C {ammeter.sym} 600 -350 0 0 {name=Vmeas1 savecurrent=true spice_ignore=0}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 580 -200 0 0 {name=M9
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 860 -280 0 0 {name=M10
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 580 -280 0 0 {name=M11
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 860 -200 0 0 {name=M12
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {lab_pin.sym} 880 -160 0 0 {name=p1 sig_type=std_logic lab=GND}
C {lab_pin.sym} 880 -380 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {ammeter.sym} 880 -350 0 0 {name=Vmeas2 savecurrent=true spice_ignore=0}
C {lab_pin.sym} 560 -240 0 0 {name=p4 sig_type=std_logic lab=in}
C {lab_pin.sym} 880 -240 0 1 {name=p5 sig_type=std_logic lab=o2}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 1730 -190 0 0 {name=M4
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 1730 -370 0 0 {name=M7
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {lab_pin.sym} 1750 -410 0 0 {name=p8 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1750 -150 0 0 {name=p9 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1710 -190 0 0 {name=p12 sig_type=std_logic lab=in}
C {lab_pin.sym} 1710 -370 0 0 {name=p22 sig_type=std_logic lab=in}
C {lab_pin.sym} 1750 -280 0 1 {name=p23 sig_type=std_logic lab=out2}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 1560 -370 0 0 {name=M13
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 1560 -310 0 0 {name=M14
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1540 -310 0 0 {name=p10 sig_type=std_logic lab=o2}
C {lab_pin.sym} 1540 -370 0 0 {name=p11 sig_type=std_logic lab=o1}
C {lab_pin.sym} 1580 -410 0 0 {name=p24 sig_type=std_logic lab=VDD2}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 1770 -580 0 1 {name=M15
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 1770 -760 0 1 {name=M16
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {lab_pin.sym} 1620 -870 0 0 {name=p27 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1620 -530 0 0 {name=p28 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1440 -760 0 0 {name=p29 sig_type=std_logic lab=in}
C {lab_pin.sym} 1440 -580 0 0 {name=p30 sig_type=std_logic lab=in}
C {lab_pin.sym} 1790 -580 0 1 {name=p31 sig_type=std_logic lab=in}
C {lab_pin.sym} 1790 -760 0 1 {name=p32 sig_type=std_logic lab=in}
C {lab_pin.sym} 1750 -670 0 1 {name=p33 sig_type=std_logic lab=out3
}
C {ammeter.sym} 1620 -840 0 0 {name=Vmeas3 savecurrent=true spice_ignore=0}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 1460 -760 0 0 {name=M17
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 1460 -700 0 0 {name=M18
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 1460 -580 0 0 {name=M19
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 1460 -640 0 0 {name=M20
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 1140 -950 0 1 {name=M21
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 1140 -1250 0 1 {name=M22
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {lab_pin.sym} 990 -1360 0 0 {name=p34 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 990 -900 0 0 {name=p35 sig_type=std_logic lab=GND}
C {lab_pin.sym} 810 -1250 0 0 {name=p36 sig_type=std_logic lab=in}
C {lab_pin.sym} 810 -950 0 0 {name=p37 sig_type=std_logic lab=in}
C {lab_pin.sym} 1160 -950 0 1 {name=p38 sig_type=std_logic lab=in}
C {lab_pin.sym} 1160 -1250 0 1 {name=p39 sig_type=std_logic lab=in}
C {lab_pin.sym} 1120 -1100 0 1 {name=p40 sig_type=std_logic lab=out4
}
C {ammeter.sym} 990 -1330 0 0 {name=Vmeas4 savecurrent=true spice_ignore=0}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 830 -1250 0 0 {name=M23
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 830 -950 0 0 {name=M25
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {res.sym} 850 -1070 0 0 {name=R1
value=100G
footprint=1206
device=resistor
m=1}
C {res.sym} 850 -1130 0 0 {name=R2
value=100G
footprint=1206
device=resistor
m=1}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2350 -2670 0 0 {name=M65
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2350 -2850 0 0 {name=M66
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2370 -2630 0 0 {name=p91 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2370 -2940 0 0 {name=p92 sig_type=std_logic lab=VDD}
C {ammeter.sym} 2370 -2910 0 0 {name=Vmeas5 savecurrent=true spice_ignore=0}
C {lab_pin.sym} 2300 -2760 0 0 {name=p95 sig_type=std_logic lab=in}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2350 -2730 0 0 {name=M67
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2350 -2790 0 0 {name=M68
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2350 -2290 0 0 {name=M69
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2350 -2470 0 0 {name=M70
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2370 -2250 0 0 {name=p96 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2370 -2560 0 0 {name=p97 sig_type=std_logic lab=VDD}
C {ammeter.sym} 2370 -2530 0 0 {name=Vmeas6 savecurrent=true spice_ignore=0}
C {lab_pin.sym} 2300 -2380 0 0 {name=p98 sig_type=std_logic lab=in}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2350 -2350 0 0 {name=M71
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2350 -2410 0 0 {name=M72
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2370 -1870 0 0 {name=p101 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2370 -2180 0 0 {name=p102 sig_type=std_logic lab=VDD}
C {ammeter.sym} 2370 -2150 0 0 {name=Vmeas7 savecurrent=true spice_ignore=0}
C {lab_pin.sym} 2300 -2000 0 0 {name=p103 sig_type=std_logic lab=in}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2350 -1970 0 0 {name=M75
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2350 -2030 0 0 {name=M76
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2370 -1490 0 0 {name=p106 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2370 -1800 0 0 {name=p107 sig_type=std_logic lab=VDD}
C {ammeter.sym} 2370 -1770 0 0 {name=Vmeas8 savecurrent=true spice_ignore=0}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2350 -1590 0 0 {name=M79
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2350 -1650 0 0 {name=M80
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2370 -1100 0 0 {name=p111 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2370 -1410 0 0 {name=p112 sig_type=std_logic lab=VDD}
C {ammeter.sym} 2370 -1380 0 0 {name=Vmeas9 savecurrent=true spice_ignore=0}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2350 -1200 0 0 {name=M83
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2350 -1260 0 0 {name=M84
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2300 -1230 0 0 {name=p41 sig_type=std_logic lab=in
}
C {lab_pin.sym} 2300 -1620 0 0 {name=p42 sig_type=std_logic lab=in
}
C {lab_pin.sym} 5160 -2760 3 1 {name=p261 sig_type=std_logic lab=o5


}
C {lab_pin.sym} 5160 -2380 3 1 {name=p262 sig_type=std_logic lab=o6


}
C {lab_pin.sym} 5160 -2000 3 1 {name=p263 sig_type=std_logic lab=o7


}
C {lab_pin.sym} 5160 -1620 3 1 {name=p264 sig_type=std_logic lab=o8


}
C {lab_pin.sym} 5160 -1230 3 1 {name=p265 sig_type=std_logic lab=o9


}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 2650 -2670 0 1 {name=M24
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 2650 -2850 0 1 {name=M26
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 2650 -2290 0 1 {name=M27
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 2650 -2470 0 1 {name=M28
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {lab_pin.sym} 2840 -1230 0 0 {name=p251 sig_type=std_logic lab=a9
}
C {lab_pin.sym} 2840 -1620 0 0 {name=p151 sig_type=std_logic lab=a8
}
C {lab_pin.sym} 2840 -2000 0 0 {name=p152 sig_type=std_logic lab=a7
}
C {lab_pin.sym} 2840 -2380 0 0 {name=p153 sig_type=std_logic lab=a6
}
C {lab_pin.sym} 2840 -2760 0 0 {name=p154 sig_type=std_logic lab=a5
}
C {lab_pin.sym} 1760 -1490 0 0 {name=p85 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1760 -1800 0 0 {name=p86 sig_type=std_logic lab=VDD}
C {ammeter.sym} 1760 -1770 0 0 {name=Vmeas30 savecurrent=true spice_ignore=0}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 1740 -1590 0 0 {name=M173
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 1740 -1650 0 0 {name=M174
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1690 -1620 0 0 {name=p87 sig_type=std_logic lab=in
}
C {lab_pin.sym} 2090 -1620 0 0 {name=p88 sig_type=std_logic lab=ab8
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 1740 -1530 0 0 {name=M177
L=0.56u
W=1.76u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 1740 -1710 0 0 {name=M178
L=0.56u
W=3.52u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1850 -1560 0 1 {name=p89 sig_type=std_logic lab=ab8b
}
C {lab_pin.sym} 1850 -1680 0 1 {name=p90 sig_type=std_logic lab=ab8t
}
C {lab_pin.sym} 1260 -1490 0 0 {name=p93 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1260 -1800 0 0 {name=p94 sig_type=std_logic lab=VDD}
C {ammeter.sym} 1260 -1770 0 0 {name=Vmeas31 savecurrent=true spice_ignore=0}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 1240 -1590 0 0 {name=M175
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 1240 -1650 0 0 {name=M176
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1190 -1620 0 0 {name=p99 sig_type=std_logic lab=in
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 1540 -1530 0 1 {name=M179
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 1540 -1710 0 1 {name=M180
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 1240 -1530 0 0 {name=M181
L=0.56u
W=1.76u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 1240 -1710 0 0 {name=M182
L=0.56u
W=3.52u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1350 -1560 0 1 {name=p100 sig_type=std_logic lab=ac8b
}
C {lab_pin.sym} 1350 -1680 0 1 {name=p104 sig_type=std_logic lab=ac8t
}
C {lab_pin.sym} 1580 -1620 0 0 {name=p105 sig_type=std_logic lab=ac8
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2350 -2090 0 0 {name=M73
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2350 -1910 0 0 {name=M74
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 2650 -2090 0 1 {name=M29
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 2650 -1910 0 1 {name=M30
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2350 -1710 0 0 {name=M77
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2350 -1530 0 0 {name=M81
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2350 -1320 0 0 {name=M78
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2350 -1140 0 0 {name=M82
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 2650 -1710 0 1 {name=M31
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 2650 -1530 0 1 {name=M32
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 2650 -1140 0 1 {name=M183
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 2650 -1320 0 1 {name=M184
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2990 -2670 0 0 {name=M33
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2990 -2850 0 0 {name=M34
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3010 -2630 0 0 {name=p43 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3010 -2940 0 0 {name=p44 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2990 -2730 0 0 {name=M35
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2990 -2790 0 0 {name=M36
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2990 -2290 0 0 {name=M37
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2990 -2470 0 0 {name=M38
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3010 -2250 0 0 {name=p46 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3010 -2560 0 0 {name=p47 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2990 -2350 0 0 {name=M39
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2990 -2410 0 0 {name=M40
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3010 -1870 0 0 {name=p49 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3010 -2180 0 0 {name=p50 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2990 -1970 0 0 {name=M41
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2990 -2030 0 0 {name=M42
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3010 -1490 0 0 {name=p52 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3010 -1800 0 0 {name=p53 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2990 -1590 0 0 {name=M43
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2990 -1650 0 0 {name=M44
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3010 -1100 0 0 {name=p54 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3010 -1410 0 0 {name=p55 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2990 -1200 0 0 {name=M45
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2990 -1260 0 0 {name=M46
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3290 -2670 0 1 {name=M47
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3290 -2850 0 1 {name=M48
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3290 -2290 0 1 {name=M49
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3290 -2470 0 1 {name=M50
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2990 -2090 0 0 {name=M51
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2990 -1910 0 0 {name=M52
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3290 -2090 0 1 {name=M53
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3290 -1910 0 1 {name=M54
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2990 -1710 0 0 {name=M55
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2990 -1530 0 0 {name=M56
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2990 -1320 0 0 {name=M57
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2990 -1140 0 0 {name=M58
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3290 -1710 0 1 {name=M59
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3290 -1530 0 1 {name=M60
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3290 -1140 0 1 {name=M61
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3290 -1320 0 1 {name=M62
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3400 -2670 0 0 {name=M63
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3400 -2850 0 0 {name=M64
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3420 -2630 0 0 {name=p45 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3420 -2940 0 0 {name=p48 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3400 -2730 0 0 {name=M85
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3400 -2790 0 0 {name=M86
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3400 -2290 0 0 {name=M87
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3400 -2470 0 0 {name=M88
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3420 -2250 0 0 {name=p51 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3420 -2560 0 0 {name=p56 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3400 -2350 0 0 {name=M89
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3400 -2410 0 0 {name=M90
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3420 -1870 0 0 {name=p57 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3420 -2180 0 0 {name=p58 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3400 -1970 0 0 {name=M91
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3400 -2030 0 0 {name=M92
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3420 -1490 0 0 {name=p59 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3420 -1800 0 0 {name=p60 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3400 -1590 0 0 {name=M93
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3400 -1650 0 0 {name=M94
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3420 -1100 0 0 {name=p61 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3420 -1410 0 0 {name=p62 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3400 -1200 0 0 {name=M95
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3400 -1260 0 0 {name=M96
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3700 -2670 0 1 {name=M97
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3700 -2850 0 1 {name=M98
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3700 -2290 0 1 {name=M99
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3700 -2470 0 1 {name=M100
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3400 -2090 0 0 {name=M101
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3400 -1910 0 0 {name=M102
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3700 -2090 0 1 {name=M103
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3700 -1910 0 1 {name=M104
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3400 -1710 0 0 {name=M105
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3400 -1530 0 0 {name=M106
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3400 -1320 0 0 {name=M107
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3400 -1140 0 0 {name=M108
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3700 -1710 0 1 {name=M109
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3700 -1530 0 1 {name=M110
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3700 -1140 0 1 {name=M111
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3700 -1320 0 1 {name=M112
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3810 -2670 0 0 {name=M113
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3810 -2850 0 0 {name=M114
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3830 -2630 0 0 {name=p67 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3830 -2940 0 0 {name=p68 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3810 -2730 0 0 {name=M115
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3810 -2790 0 0 {name=M116
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3810 -2290 0 0 {name=M117
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3810 -2470 0 0 {name=M118
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3830 -2250 0 0 {name=p69 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3830 -2560 0 0 {name=p70 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3810 -2350 0 0 {name=M119
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3810 -2410 0 0 {name=M120
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3830 -1870 0 0 {name=p71 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3830 -2180 0 0 {name=p72 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3810 -1970 0 0 {name=M121
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3810 -2030 0 0 {name=M122
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3830 -1490 0 0 {name=p73 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3830 -1800 0 0 {name=p74 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3810 -1590 0 0 {name=M123
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3810 -1650 0 0 {name=M124
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3830 -1100 0 0 {name=p75 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3830 -1410 0 0 {name=p76 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3810 -1200 0 0 {name=M125
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3810 -1260 0 0 {name=M126
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4110 -2670 0 1 {name=M127
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4110 -2850 0 1 {name=M128
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4110 -2290 0 1 {name=M129
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4110 -2470 0 1 {name=M130
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3810 -2090 0 0 {name=M131
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3810 -1910 0 0 {name=M132
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4110 -2090 0 1 {name=M133
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4110 -1910 0 1 {name=M134
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3810 -1710 0 0 {name=M135
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3810 -1530 0 0 {name=M136
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3810 -1320 0 0 {name=M137
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3810 -1140 0 0 {name=M138
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4110 -1710 0 1 {name=M139
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4110 -1530 0 1 {name=M140
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4110 -1140 0 1 {name=M141
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4110 -1320 0 1 {name=M142
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4220 -2670 0 0 {name=M143
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4220 -2850 0 0 {name=M144
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4240 -2630 0 0 {name=p79 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4240 -2940 0 0 {name=p80 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4220 -2730 0 0 {name=M145
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4220 -2790 0 0 {name=M146
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4220 -2290 0 0 {name=M147
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4220 -2470 0 0 {name=M148
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4240 -2250 0 0 {name=p81 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4240 -2560 0 0 {name=p82 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4220 -2350 0 0 {name=M149
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4220 -2410 0 0 {name=M150
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4240 -1870 0 0 {name=p108 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4240 -2180 0 0 {name=p109 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4220 -1970 0 0 {name=M151
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4220 -2030 0 0 {name=M152
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4240 -1490 0 0 {name=p110 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4240 -1800 0 0 {name=p113 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4220 -1590 0 0 {name=M153
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4220 -1650 0 0 {name=M154
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4240 -1100 0 0 {name=p114 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4240 -1410 0 0 {name=p115 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4220 -1200 0 0 {name=M155
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4220 -1260 0 0 {name=M156
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4520 -2670 0 1 {name=M157
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4520 -2850 0 1 {name=M158
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4520 -2290 0 1 {name=M159
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4520 -2470 0 1 {name=M160
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4220 -2090 0 0 {name=M161
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4220 -1910 0 0 {name=M162
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4520 -2090 0 1 {name=M163
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4520 -1910 0 1 {name=M164
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4220 -1710 0 0 {name=M165
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4220 -1530 0 0 {name=M166
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4220 -1320 0 0 {name=M167
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4220 -1140 0 0 {name=M168
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4520 -1710 0 1 {name=M169
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4520 -1530 0 1 {name=M170
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4520 -1140 0 1 {name=M171
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4520 -1320 0 1 {name=M172
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4630 -2670 0 0 {name=M185
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4630 -2850 0 0 {name=M186
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4650 -2630 0 0 {name=p118 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4650 -2940 0 0 {name=p119 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4630 -2730 0 0 {name=M187
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4630 -2790 0 0 {name=M188
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4630 -2290 0 0 {name=M189
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4630 -2470 0 0 {name=M190
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4650 -2250 0 0 {name=p120 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4650 -2560 0 0 {name=p121 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4630 -2350 0 0 {name=M191
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4630 -2410 0 0 {name=M192
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4650 -1870 0 0 {name=p122 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4650 -2180 0 0 {name=p123 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4630 -1970 0 0 {name=M193
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4630 -2030 0 0 {name=M194
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4650 -1490 0 0 {name=p124 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4650 -1800 0 0 {name=p125 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4630 -1590 0 0 {name=M195
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4630 -1650 0 0 {name=M196
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4650 -1100 0 0 {name=p126 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4650 -1410 0 0 {name=p127 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4630 -1200 0 0 {name=M197
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4630 -1260 0 0 {name=M198
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4930 -2670 0 1 {name=M199
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4930 -2850 0 1 {name=M200
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4930 -2290 0 1 {name=M201
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4930 -2470 0 1 {name=M202
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4630 -2090 0 0 {name=M203
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4630 -1910 0 0 {name=M204
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4930 -2090 0 1 {name=M205
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4930 -1910 0 1 {name=M206
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4630 -1710 0 0 {name=M207
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4630 -1530 0 0 {name=M208
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4630 -1320 0 0 {name=M209
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4630 -1140 0 0 {name=M210
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4930 -1710 0 1 {name=M211
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4930 -1530 0 1 {name=M212
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4930 -1140 0 1 {name=M213
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4930 -1320 0 1 {name=M214
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2490 -5030 0 0 {name=M215
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2490 -5210 0 0 {name=M216
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2510 -4990 0 0 {name=p63 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2510 -5300 0 0 {name=p64 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2490 -5090 0 0 {name=M217
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2490 -5150 0 0 {name=M218
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2490 -4650 0 0 {name=M219
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2490 -4830 0 0 {name=M220
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2510 -4610 0 0 {name=p65 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2510 -4920 0 0 {name=p66 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2490 -4710 0 0 {name=M221
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2490 -4770 0 0 {name=M222
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2510 -4230 0 0 {name=p77 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2510 -4540 0 0 {name=p78 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2490 -4330 0 0 {name=M223
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2490 -4390 0 0 {name=M224
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2510 -3850 0 0 {name=p83 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2510 -4160 0 0 {name=p84 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2490 -3950 0 0 {name=M225
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2490 -4010 0 0 {name=M226
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2510 -3460 0 0 {name=p116 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2510 -3770 0 0 {name=p117 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2490 -3560 0 0 {name=M227
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2490 -3620 0 0 {name=M228
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 2790 -5030 0 1 {name=M229
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 2790 -5210 0 1 {name=M230
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 2790 -4650 0 1 {name=M231
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 2790 -4830 0 1 {name=M232
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2490 -4450 0 0 {name=M233
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2490 -4270 0 0 {name=M234
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 2790 -4450 0 1 {name=M235
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 2790 -4270 0 1 {name=M236
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2490 -4070 0 0 {name=M237
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2490 -3890 0 0 {name=M238
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2490 -3680 0 0 {name=M239
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2490 -3500 0 0 {name=M240
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 2790 -4070 0 1 {name=M241
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 2790 -3890 0 1 {name=M242
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 2790 -3500 0 1 {name=M243
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 2790 -3680 0 1 {name=M244
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2900 -5030 0 0 {name=M245
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2900 -5210 0 0 {name=M246
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2920 -4990 0 0 {name=p128 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2920 -5300 0 0 {name=p129 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2900 -5090 0 0 {name=M247
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2900 -5150 0 0 {name=M248
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2900 -4650 0 0 {name=M249
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2900 -4830 0 0 {name=M250
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2920 -4610 0 0 {name=p130 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2920 -4920 0 0 {name=p131 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2900 -4710 0 0 {name=M251
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2900 -4770 0 0 {name=M252
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2920 -4230 0 0 {name=p132 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2920 -4540 0 0 {name=p133 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2900 -4330 0 0 {name=M253
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2900 -4390 0 0 {name=M254
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2920 -3850 0 0 {name=p134 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2920 -4160 0 0 {name=p135 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2900 -3950 0 0 {name=M255
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2900 -4010 0 0 {name=M256
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2920 -3460 0 0 {name=p136 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2920 -3770 0 0 {name=p137 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2900 -3560 0 0 {name=M257
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2900 -3620 0 0 {name=M258
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3200 -5030 0 1 {name=M259
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3200 -5210 0 1 {name=M260
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3200 -4650 0 1 {name=M261
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3200 -4830 0 1 {name=M262
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2900 -4450 0 0 {name=M263
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2900 -4270 0 0 {name=M264
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3200 -4450 0 1 {name=M265
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3200 -4270 0 1 {name=M266
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2900 -4070 0 0 {name=M267
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2900 -3890 0 0 {name=M268
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 2900 -3680 0 0 {name=M269
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 2900 -3500 0 0 {name=M270
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3200 -4070 0 1 {name=M271
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3200 -3890 0 1 {name=M272
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3200 -3500 0 1 {name=M273
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3200 -3680 0 1 {name=M274
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3310 -5030 0 0 {name=M275
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3310 -5210 0 0 {name=M276
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3330 -4990 0 0 {name=p138 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3330 -5300 0 0 {name=p139 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3310 -5090 0 0 {name=M277
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3310 -5150 0 0 {name=M278
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3310 -4650 0 0 {name=M279
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3310 -4830 0 0 {name=M280
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3330 -4610 0 0 {name=p140 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3330 -4920 0 0 {name=p141 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3310 -4710 0 0 {name=M281
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3310 -4770 0 0 {name=M282
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3330 -4230 0 0 {name=p142 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3330 -4540 0 0 {name=p143 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3310 -4330 0 0 {name=M283
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3310 -4390 0 0 {name=M284
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3330 -3850 0 0 {name=p144 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3330 -4160 0 0 {name=p145 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3310 -3950 0 0 {name=M285
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3310 -4010 0 0 {name=M286
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3330 -3460 0 0 {name=p146 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3330 -3770 0 0 {name=p147 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3310 -3560 0 0 {name=M287
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3310 -3620 0 0 {name=M288
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3610 -5030 0 1 {name=M289
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3610 -5210 0 1 {name=M290
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3610 -4650 0 1 {name=M291
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3610 -4830 0 1 {name=M292
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3310 -4450 0 0 {name=M293
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3310 -4270 0 0 {name=M294
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3610 -4450 0 1 {name=M295
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3610 -4270 0 1 {name=M296
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3310 -4070 0 0 {name=M297
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3310 -3890 0 0 {name=M298
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3310 -3680 0 0 {name=M299
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3310 -3500 0 0 {name=M300
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3610 -4070 0 1 {name=M301
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3610 -3890 0 1 {name=M302
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 3610 -3500 0 1 {name=M303
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 3610 -3680 0 1 {name=M304
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3720 -5030 0 0 {name=M305
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3720 -5210 0 0 {name=M306
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3740 -4990 0 0 {name=p148 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3740 -5300 0 0 {name=p149 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3720 -5090 0 0 {name=M307
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3720 -5150 0 0 {name=M308
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3720 -4650 0 0 {name=M309
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3720 -4830 0 0 {name=M310
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3740 -4610 0 0 {name=p150 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3740 -4920 0 0 {name=p155 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3720 -4710 0 0 {name=M311
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3720 -4770 0 0 {name=M312
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3740 -4230 0 0 {name=p156 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3740 -4540 0 0 {name=p157 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3720 -4330 0 0 {name=M313
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3720 -4390 0 0 {name=M314
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3740 -3850 0 0 {name=p158 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3740 -4160 0 0 {name=p159 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3720 -3950 0 0 {name=M315
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3720 -4010 0 0 {name=M316
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3740 -3460 0 0 {name=p160 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3740 -3770 0 0 {name=p161 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3720 -3560 0 0 {name=M317
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3720 -3620 0 0 {name=M318
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4020 -5030 0 1 {name=M319
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4020 -5210 0 1 {name=M320
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4020 -4650 0 1 {name=M321
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4020 -4830 0 1 {name=M322
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3720 -4450 0 0 {name=M323
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3720 -4270 0 0 {name=M324
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4020 -4450 0 1 {name=M325
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4020 -4270 0 1 {name=M326
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3720 -4070 0 0 {name=M327
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3720 -3890 0 0 {name=M328
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 3720 -3680 0 0 {name=M329
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 3720 -3500 0 0 {name=M330
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4020 -4070 0 1 {name=M331
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4020 -3890 0 1 {name=M332
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4020 -3500 0 1 {name=M333
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4020 -3680 0 1 {name=M334
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4130 -5030 0 0 {name=M335
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4130 -5210 0 0 {name=M336
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4150 -4990 0 0 {name=p162 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4150 -5300 0 0 {name=p163 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4130 -5090 0 0 {name=M337
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4130 -5150 0 0 {name=M338
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4130 -4650 0 0 {name=M339
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4130 -4830 0 0 {name=M340
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4150 -4610 0 0 {name=p164 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4150 -4920 0 0 {name=p165 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4130 -4710 0 0 {name=M341
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4130 -4770 0 0 {name=M342
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4150 -4230 0 0 {name=p166 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4150 -4540 0 0 {name=p167 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4130 -4330 0 0 {name=M343
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4130 -4390 0 0 {name=M344
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4150 -3850 0 0 {name=p168 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4150 -4160 0 0 {name=p169 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4130 -3950 0 0 {name=M345
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4130 -4010 0 0 {name=M346
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4150 -3460 0 0 {name=p170 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4150 -3770 0 0 {name=p171 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4130 -3560 0 0 {name=M347
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4130 -3620 0 0 {name=M348
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4430 -5030 0 1 {name=M349
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4430 -5210 0 1 {name=M350
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4430 -4650 0 1 {name=M351
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4430 -4830 0 1 {name=M352
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4130 -4450 0 0 {name=M353
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4130 -4270 0 0 {name=M354
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4430 -4450 0 1 {name=M355
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4430 -4270 0 1 {name=M356
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4130 -4070 0 0 {name=M357
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4130 -3890 0 0 {name=M358
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4130 -3680 0 0 {name=M359
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4130 -3500 0 0 {name=M360
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4430 -4070 0 1 {name=M361
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4430 -3890 0 1 {name=M362
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4430 -3500 0 1 {name=M363
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4430 -3680 0 1 {name=M364
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4530 -5030 0 0 {name=M365
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4530 -5210 0 0 {name=M366
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4550 -4990 0 0 {name=p172 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4550 -5300 0 0 {name=p173 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4530 -5090 0 0 {name=M367
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4530 -5150 0 0 {name=M368
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4530 -4650 0 0 {name=M369
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4530 -4830 0 0 {name=M370
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4550 -4610 0 0 {name=p174 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4550 -4920 0 0 {name=p175 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4530 -4710 0 0 {name=M371
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4530 -4770 0 0 {name=M372
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4550 -4230 0 0 {name=p176 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4550 -4540 0 0 {name=p177 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4530 -4330 0 0 {name=M373
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4530 -4390 0 0 {name=M374
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4550 -3850 0 0 {name=p178 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4550 -4160 0 0 {name=p179 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4530 -3950 0 0 {name=M375
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4530 -4010 0 0 {name=M376
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4550 -3460 0 0 {name=p180 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4550 -3770 0 0 {name=p181 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4530 -3560 0 0 {name=M377
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4530 -3620 0 0 {name=M378
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4830 -5030 0 1 {name=M379
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4830 -5210 0 1 {name=M380
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4830 -4650 0 1 {name=M381
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4830 -4830 0 1 {name=M382
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4530 -4450 0 0 {name=M383
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4530 -4270 0 0 {name=M384
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4830 -4450 0 1 {name=M385
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4830 -4270 0 1 {name=M386
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4530 -4070 0 0 {name=M387
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4530 -3890 0 0 {name=M388
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4530 -3680 0 0 {name=M389
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4530 -3500 0 0 {name=M390
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4830 -4070 0 1 {name=M391
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4830 -3890 0 1 {name=M392
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 4830 -3500 0 1 {name=M393
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 4830 -3680 0 1 {name=M394
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4940 -5030 0 0 {name=M395
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4940 -5210 0 0 {name=M396
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4960 -4990 0 0 {name=p182 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4960 -5300 0 0 {name=p183 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4940 -5090 0 0 {name=M397
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4940 -5150 0 0 {name=M398
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4940 -4650 0 0 {name=M399
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4940 -4830 0 0 {name=M400
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4960 -4610 0 0 {name=p184 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4960 -4920 0 0 {name=p185 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4940 -4710 0 0 {name=M401
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4940 -4770 0 0 {name=M402
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4960 -4230 0 0 {name=p186 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4960 -4540 0 0 {name=p187 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4940 -4330 0 0 {name=M403
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4940 -4390 0 0 {name=M404
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4960 -3850 0 0 {name=p188 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4960 -4160 0 0 {name=p189 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4940 -3950 0 0 {name=M405
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4940 -4010 0 0 {name=M406
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 4960 -3460 0 0 {name=p190 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4960 -3770 0 0 {name=p191 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4940 -3560 0 0 {name=M407
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4940 -3620 0 0 {name=M408
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 5240 -5030 0 1 {name=M409
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 5240 -5210 0 1 {name=M410
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 5240 -4650 0 1 {name=M411
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 5240 -4830 0 1 {name=M412
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4940 -4450 0 0 {name=M413
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4940 -4270 0 0 {name=M414
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 5240 -4450 0 1 {name=M415
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 5240 -4270 0 1 {name=M416
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4940 -4070 0 0 {name=M417
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4940 -3890 0 0 {name=M418
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 4940 -3680 0 0 {name=M419
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 4940 -3500 0 0 {name=M420
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 5240 -4070 0 1 {name=M421
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 5240 -3890 0 1 {name=M422
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 5240 -3500 0 1 {name=M423
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 5240 -3680 0 1 {name=M424
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5350 -5030 0 0 {name=M425
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5350 -5210 0 0 {name=M426
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5370 -4990 0 0 {name=p192 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5370 -5300 0 0 {name=p193 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5350 -5090 0 0 {name=M427
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5350 -5150 0 0 {name=M428
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5350 -4650 0 0 {name=M429
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5350 -4830 0 0 {name=M430
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5370 -4610 0 0 {name=p194 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5370 -4920 0 0 {name=p195 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5350 -4710 0 0 {name=M431
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5350 -4770 0 0 {name=M432
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5370 -4230 0 0 {name=p196 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5370 -4540 0 0 {name=p197 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5350 -4330 0 0 {name=M433
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5350 -4390 0 0 {name=M434
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5370 -3850 0 0 {name=p198 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5370 -4160 0 0 {name=p199 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5350 -3950 0 0 {name=M435
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5350 -4010 0 0 {name=M436
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5370 -3460 0 0 {name=p200 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5370 -3770 0 0 {name=p201 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5350 -3560 0 0 {name=M437
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5350 -3620 0 0 {name=M438
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 5650 -5030 0 1 {name=M439
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 5650 -5210 0 1 {name=M440
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 5650 -4650 0 1 {name=M441
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 5650 -4830 0 1 {name=M442
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5350 -4450 0 0 {name=M443
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5350 -4270 0 0 {name=M444
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 5650 -4450 0 1 {name=M445
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 5650 -4270 0 1 {name=M446
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5350 -4070 0 0 {name=M447
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5350 -3890 0 0 {name=M448
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5350 -3680 0 0 {name=M449
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5350 -3500 0 0 {name=M450
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 5650 -4070 0 1 {name=M451
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 5650 -3890 0 1 {name=M452
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 5650 -3500 0 1 {name=M453
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 5650 -3680 0 1 {name=M454
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5760 -5030 0 0 {name=M455
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5760 -5210 0 0 {name=M456
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5780 -4990 0 0 {name=p202 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5780 -5300 0 0 {name=p203 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5760 -5090 0 0 {name=M457
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5760 -5150 0 0 {name=M458
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5760 -4650 0 0 {name=M459
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5760 -4830 0 0 {name=M460
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5780 -4610 0 0 {name=p204 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5780 -4920 0 0 {name=p205 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5760 -4710 0 0 {name=M461
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5760 -4770 0 0 {name=M462
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5780 -4230 0 0 {name=p206 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5780 -4540 0 0 {name=p207 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5760 -4330 0 0 {name=M463
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5760 -4390 0 0 {name=M464
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5780 -3850 0 0 {name=p208 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5780 -4160 0 0 {name=p209 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5760 -3950 0 0 {name=M465
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5760 -4010 0 0 {name=M466
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 5780 -3460 0 0 {name=p210 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5780 -3770 0 0 {name=p211 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5760 -3560 0 0 {name=M467
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5760 -3620 0 0 {name=M468
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 6060 -5030 0 1 {name=M469
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 6060 -5210 0 1 {name=M470
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 6060 -4650 0 1 {name=M471
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 6060 -4830 0 1 {name=M472
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5760 -4450 0 0 {name=M473
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5760 -4270 0 0 {name=M474
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 6060 -4450 0 1 {name=M475
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 6060 -4270 0 1 {name=M476
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5760 -4070 0 0 {name=M477
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5760 -3890 0 0 {name=M478
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 5760 -3680 0 0 {name=M479
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 5760 -3500 0 0 {name=M480
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 6060 -4070 0 1 {name=M481
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 6060 -3890 0 1 {name=M482
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 6060 -3500 0 1 {name=M483
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 6060 -3680 0 1 {name=M484
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 6170 -5030 0 0 {name=M485
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 6170 -5210 0 0 {name=M486
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 6190 -4990 0 0 {name=p212 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6190 -5300 0 0 {name=p213 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 6170 -5090 0 0 {name=M487
L=0.28u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 6170 -5150 0 0 {name=M488
L=0.28u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 6170 -4650 0 0 {name=M489
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 6170 -4830 0 0 {name=M490
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 6190 -4610 0 0 {name=p214 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6190 -4920 0 0 {name=p215 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 6170 -4710 0 0 {name=M491
L=0.56u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 6170 -4770 0 0 {name=M492
L=0.56u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 6190 -4230 0 0 {name=p216 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6190 -4540 0 0 {name=p217 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 6170 -4330 0 0 {name=M493
L=1.12u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 6170 -4390 0 0 {name=M494
L=1.12u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 6190 -3850 0 0 {name=p218 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6190 -4160 0 0 {name=p219 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 6170 -3950 0 0 {name=M495
L=2.24u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 6170 -4010 0 0 {name=M496
L=2.24u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 6190 -3460 0 0 {name=p220 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6190 -3770 0 0 {name=p221 sig_type=std_logic lab=VDD}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 6170 -3560 0 0 {name=M497
L=4.48u
W=0.22u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 6170 -3620 0 0 {name=M498
L=4.48u
W=0.44u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 6470 -5030 0 1 {name=M499
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 6470 -5210 0 1 {name=M500
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 6470 -4650 0 1 {name=M501
L=0.70u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 6470 -4830 0 1 {name=M502
L=0.55u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 6170 -4450 0 0 {name=M503
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 6170 -4270 0 0 {name=M504
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 6470 -4450 0 1 {name=M505
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 6470 -4270 0 1 {name=M506
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 6170 -4070 0 0 {name=M507
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 6170 -3890 0 0 {name=M508
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_03v3.sym} 6170 -3680 0 0 {name=M509
L=0.28u
W=0.88u
body=VDD
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_03v3.sym} 6170 -3500 0 0 {name=M510
L=0.28u
W=0.44u
body=GND
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 6470 -4070 0 1 {name=M511
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 6470 -3890 0 1 {name=M512
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/nfet3_06v0.sym} 6470 -3500 0 1 {name=M513
L=1.4u
W=0.30u
body=BN
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180mcu_fd_pr/pfet3_06v0.sym} 6470 -3680 0 1 {name=M514
L=1.1u
W=0.60u
body=BP
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {lab_pin.sym} 6450 -3590 0 1 {name=p222 sig_type=std_logic lab=o9d}
C {lab_pin.sym} 6450 -3980 0 1 {name=p223 sig_type=std_logic lab=o8d}
C {lab_pin.sym} 6450 -4360 0 1 {name=p224 sig_type=std_logic lab=o7d}
C {lab_pin.sym} 6450 -4740 0 1 {name=p225 sig_type=std_logic lab=o6d}
C {lab_pin.sym} 6450 -5120 0 1 {name=p226 sig_type=std_logic lab=o5d}
C {lab_pin.sym} 2440 -5120 0 0 {name=p227 sig_type=std_logic lab=ind}
C {lab_pin.sym} 2440 -4740 0 0 {name=p228 sig_type=std_logic lab=ind}
C {lab_pin.sym} 2440 -4360 0 0 {name=p229 sig_type=std_logic lab=ind}
C {lab_pin.sym} 2440 -3980 0 0 {name=p230 sig_type=std_logic lab=ind}
C {lab_pin.sym} 2440 -3590 0 0 {name=p231 sig_type=std_logic lab=ind}
C {ammeter.sym} 2510 -5270 0 0 {name=Vmeas15 savecurrent=true spice_ignore=0}
C {ammeter.sym} 2510 -4890 0 0 {name=Vmeas16 savecurrent=true spice_ignore=0}
C {ammeter.sym} 2510 -4510 0 0 {name=Vmeas17 savecurrent=true spice_ignore=0}
C {ammeter.sym} 2510 -4130 0 0 {name=Vmeas18 savecurrent=true spice_ignore=0}
C {ammeter.sym} 2510 -3740 0 0 {name=Vmeas19 savecurrent=true spice_ignore=0}
